v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {Clock Pulse Delay Line
} 110 -310 0 0 0.4 0.4 {}
T {Bit Calculations with CRS} 120 -1290 0 0 0.4 0.4 {}
T {Digital Error Correction with parallel output bus
} 120 -1880 0 0 0.4 0.4 {}
N 350 -180 350 -160 {
lab=clk_1.2}
N 350 -160 370 -160 {
lab=clk_1.2}
N 360 -220 370 -220 {
lab=clk}
N 370 -220 370 -180 {
lab=clk}
N 550 -180 550 -160 {
lab=clk_1.3}
N 550 -160 570 -160 {
lab=clk_1.3}
N 560 -220 570 -220 {
lab=clk}
N 570 -220 570 -180 {
lab=clk}
N 360 -160 360 -130 {
lab=clk_1.2}
N 560 -160 560 -130 {
lab=clk_1.3}
N 750 -180 750 -160 {
lab=clk_2}
N 750 -160 770 -160 {
lab=clk_2}
N 760 -220 770 -220 {
lab=clk}
N 770 -220 770 -180 {
lab=clk}
N 950 -180 950 -160 {
lab=clk_3}
N 950 -160 970 -160 {
lab=clk_3}
N 960 -220 970 -220 {
lab=clk}
N 970 -220 970 -180 {
lab=clk}
N 760 -160 760 -130 {
lab=clk_2}
N 960 -160 960 -130 {
lab=clk_3}
N 1150 -180 1150 -160 {
lab=clk_4.5}
N 1150 -160 1170 -160 {
lab=clk_4.5}
N 1160 -220 1170 -220 {
lab=clk}
N 1170 -220 1170 -180 {
lab=clk}
N 1350 -180 1350 -160 {
lab=clk_4.6}
N 1350 -160 1370 -160 {
lab=clk_4.6}
N 1360 -220 1370 -220 {
lab=clk}
N 1370 -220 1370 -180 {
lab=clk}
N 1160 -160 1160 -130 {
lab=clk_4.5}
N 1360 -160 1360 -130 {
lab=clk_4.6}
N 1550 -180 1550 -160 {
lab=clk_4.7}
N 1550 -160 1570 -160 {
lab=clk_4.7}
N 1560 -220 1570 -220 {
lab=clk}
N 1570 -220 1570 -180 {
lab=clk}
N 1750 -180 1750 -160 {
lab=clk_5}
N 1750 -160 1770 -160 {
lab=clk_5}
N 1760 -220 1770 -220 {
lab=clk}
N 1770 -220 1770 -180 {
lab=clk}
N 1560 -160 1560 -130 {
lab=clk_4.7}
N 1760 -160 1760 -130 {
lab=clk_5}
N 1950 -180 1950 -160 {
lab=clk_6}
N 1950 -160 1970 -160 {
lab=clk_6}
N 1960 -220 1970 -220 {
lab=clk}
N 1970 -220 1970 -180 {
lab=clk}
N 2150 -180 2150 -160 {
lab=clk_7}
N 2150 -160 2170 -160 {
lab=clk_7}
N 2160 -220 2170 -220 {
lab=clk}
N 2170 -220 2170 -180 {
lab=clk}
N 1960 -160 1960 -130 {
lab=clk_6}
N 2160 -160 2160 -130 {
lab=clk_7}
N 2350 -180 2350 -160 {
lab=clk_8.9}
N 2350 -160 2370 -160 {
lab=clk_8.9}
N 2360 -220 2370 -220 {
lab=clk}
N 2370 -220 2370 -180 {
lab=clk}
N 2550 -180 2550 -160 {
lab=clk_8.10}
N 2550 -160 2570 -160 {
lab=clk_8.10}
N 2560 -220 2570 -220 {
lab=clk}
N 2570 -220 2570 -180 {
lab=clk}
N 2360 -160 2360 -130 {
lab=clk_8.9}
N 2560 -160 2560 -130 {
lab=clk_8.10}
N 2750 -180 2750 -160 {
lab=clk_8.11}
N 2750 -160 2770 -160 {
lab=clk_8.11}
N 2760 -220 2770 -220 {
lab=clk}
N 2770 -220 2770 -180 {
lab=clk}
N 2950 -180 2950 -160 {
lab=clk_9}
N 2950 -160 2970 -160 {
lab=clk_9}
N 2960 -220 2970 -220 {
lab=clk}
N 2970 -220 2970 -180 {
lab=clk}
N 2760 -160 2760 -130 {
lab=clk_8.11}
N 2960 -160 2960 -130 {
lab=clk_9}
N 3150 -180 3150 -160 {
lab=clk_10}
N 3150 -160 3170 -160 {
lab=clk_10}
N 3160 -220 3170 -220 {
lab=clk}
N 3170 -220 3170 -180 {
lab=clk}
N 3350 -180 3350 -160 {
lab=clk_11}
N 3350 -160 3370 -160 {
lab=clk_11}
N 3360 -220 3370 -220 {
lab=clk}
N 3370 -220 3370 -180 {
lab=clk}
N 3160 -160 3160 -130 {
lab=clk_10}
N 3360 -160 3360 -130 {
lab=clk_11}
N 3550 -180 3550 -160 {
lab=clk_12}
N 3550 -160 3570 -160 {
lab=clk_12}
N 3560 -220 3570 -220 {
lab=clk}
N 3570 -220 3570 -180 {
lab=clk}
N 3750 -180 3750 -160 {
lab=clk_13}
N 3750 -160 3770 -160 {
lab=clk_13}
N 3760 -220 3770 -220 {
lab=clk}
N 3770 -220 3770 -180 {
lab=clk}
N 3560 -160 3560 -130 {
lab=clk_12}
N 3760 -160 3760 -130 {
lab=clk_13}
N 160 -220 170 -220 {
lab=clk}
N 170 -220 170 -180 {
lab=clk}
N 160 -160 170 -160 {
lab=clk_pulse}
N 3950 -180 3950 -160 {
lab=clk_dump_bus}
N 3950 -160 3970 -160 {
lab=clk_dump_bus}
N 3960 -220 3970 -220 {
lab=clk}
N 3970 -220 3970 -180 {
lab=clk}
N 3960 -160 3960 -130 {
lab=clk_dump_bus}
N 4150 -180 4170 -180 {
lab=RESET}
N 290 -970 290 -950 {
lab=RESET}
N 290 -950 300 -950 {
lab=RESET}
N 270 -970 270 -930 {
lab=Vcmp}
N 270 -930 300 -930 {
lab=Vcmp}
N 250 -970 250 -930 {
lab=#net1}
N 230 -810 230 -790 {
lab=clk_1.2}
N 270 -1180 270 -1150 {
lab=SW1.2p}
N 270 -1180 280 -1180 {
lab=SW1.2p}
N 250 -1200 250 -1150 {
lab=SW1.2n}
N 250 -1200 280 -1200 {
lab=SW1.2n}
N 230 -1200 250 -1200 {
lab=SW1.2n}
N 220 -1200 230 -1200 {
lab=bit1.2}
N 500 -970 500 -950 {
lab=RESET}
N 500 -950 510 -950 {
lab=RESET}
N 480 -970 480 -930 {
lab=Vcmp}
N 480 -930 510 -930 {
lab=Vcmp}
N 460 -970 460 -930 {
lab=#net2}
N 440 -810 440 -790 {
lab=clk_1.3}
N 480 -1180 480 -1150 {
lab=SW1.3p}
N 480 -1180 490 -1180 {
lab=SW1.3p}
N 460 -1200 460 -1150 {
lab=SW1.3n}
N 460 -1200 490 -1200 {
lab=SW1.3n}
N 440 -1200 460 -1200 {
lab=SW1.3n}
N 430 -1200 440 -1200 {
lab=bit1.3}
N 710 -970 710 -950 {
lab=RESET}
N 710 -950 720 -950 {
lab=RESET}
N 690 -970 690 -930 {
lab=Vcmp}
N 690 -930 720 -930 {
lab=Vcmp}
N 670 -970 670 -930 {
lab=#net3}
N 690 -1180 690 -1150 {
lab=SW2p}
N 690 -1180 700 -1180 {
lab=SW2p}
N 670 -1200 670 -1150 {
lab=SW2n}
N 670 -1200 700 -1200 {
lab=SW2n}
N 650 -1200 670 -1200 {
lab=SW2n}
N 640 -1200 650 -1200 {
lab=bit2}
N 670 -930 670 -760 {
lab=#net3}
N 650 -770 650 -760 {
lab=#net4}
N 270 -770 650 -770 {
lab=#net4}
N 270 -810 270 -770 {
lab=#net4}
N 650 -550 650 -530 {
lab=clk_2}
N 670 -550 670 -530 {
lab=#net5}
N 620 -530 650 -530 {
lab=clk_2}
N 650 -410 650 -390 {
lab=bit2}
N 690 -410 690 -390 {
lab=Vcmp}
N 900 -970 900 -950 {
lab=RESET}
N 900 -950 910 -950 {
lab=RESET}
N 880 -970 880 -930 {
lab=Vcmp}
N 880 -930 910 -930 {
lab=Vcmp}
N 860 -970 860 -930 {
lab=#net6}
N 880 -1180 880 -1150 {
lab=SW3p}
N 880 -1180 890 -1180 {
lab=SW3p}
N 860 -1200 860 -1150 {
lab=SW3n}
N 860 -1200 890 -1200 {
lab=SW3n}
N 840 -1200 860 -1200 {
lab=SW3n}
N 830 -1200 840 -1200 {
lab=bit3}
N 860 -930 860 -760 {
lab=#net6}
N 840 -770 840 -760 {
lab=#net7}
N 840 -550 840 -530 {
lab=clk_3}
N 860 -550 860 -530 {
lab=#net8}
N 810 -530 840 -530 {
lab=clk_3}
N 840 -410 840 -390 {
lab=bit3}
N 880 -410 880 -390 {
lab=Vcmp}
N 480 -780 840 -780 {
lab=#net7}
N 480 -810 480 -790 {
lab=#net7}
N 1100 -970 1100 -950 {
lab=RESET}
N 1100 -950 1110 -950 {
lab=RESET}
N 1080 -970 1080 -930 {
lab=Vcmp}
N 1080 -930 1110 -930 {
lab=Vcmp}
N 1060 -970 1060 -930 {
lab=#net9}
N 1040 -810 1040 -790 {
lab=clk_4.5}
N 1080 -1180 1080 -1150 {
lab=SW4.5p}
N 1080 -1180 1090 -1180 {
lab=SW4.5p}
N 1060 -1200 1060 -1150 {
lab=SW4.5n}
N 1060 -1200 1090 -1200 {
lab=SW4.5n}
N 1040 -1200 1060 -1200 {
lab=SW4.5n}
N 1030 -1200 1040 -1200 {
lab=bit4.5}
N 1310 -970 1310 -950 {
lab=RESET}
N 1310 -950 1320 -950 {
lab=RESET}
N 1290 -970 1290 -930 {
lab=Vcmp}
N 1290 -930 1320 -930 {
lab=Vcmp}
N 1270 -970 1270 -930 {
lab=#net10}
N 1250 -810 1250 -790 {
lab=clk_4.6}
N 1290 -1180 1290 -1150 {
lab=SW4.6p}
N 1290 -1180 1300 -1180 {
lab=SW4.6p}
N 1270 -1200 1270 -1150 {
lab=SW4.6n}
N 1270 -1200 1300 -1200 {
lab=SW4.6n}
N 1250 -1200 1270 -1200 {
lab=SW4.6n}
N 1240 -1200 1250 -1200 {
lab=bit4.6}
N 1720 -970 1720 -950 {
lab=RESET}
N 1720 -950 1730 -950 {
lab=RESET}
N 1700 -970 1700 -930 {
lab=Vcmp}
N 1700 -930 1730 -930 {
lab=Vcmp}
N 1680 -970 1680 -930 {
lab=#net11}
N 1700 -1180 1700 -1150 {
lab=SW5p}
N 1700 -1180 1710 -1180 {
lab=SW5p}
N 1680 -1200 1680 -1150 {
lab=SW5n}
N 1680 -1200 1710 -1200 {
lab=SW5n}
N 1660 -1200 1680 -1200 {
lab=SW5n}
N 1650 -1200 1660 -1200 {
lab=bit5}
N 1680 -930 1680 -760 {
lab=#net11}
N 1660 -770 1660 -760 {
lab=#net12}
N 1080 -810 1080 -770 {
lab=#net12}
N 1660 -550 1660 -530 {
lab=clk_5}
N 1680 -550 1680 -530 {
lab=#net13}
N 1630 -530 1660 -530 {
lab=clk_5}
N 1660 -410 1660 -390 {
lab=bit5}
N 1700 -410 1700 -390 {
lab=Vcmp}
N 1910 -970 1910 -950 {
lab=RESET}
N 1910 -950 1920 -950 {
lab=RESET}
N 1890 -970 1890 -930 {
lab=Vcmp}
N 1890 -930 1920 -930 {
lab=Vcmp}
N 1870 -970 1870 -930 {
lab=#net14}
N 1890 -1180 1890 -1150 {
lab=SW6p}
N 1890 -1180 1900 -1180 {
lab=SW6p}
N 1870 -1200 1870 -1150 {
lab=SW6n}
N 1870 -1200 1900 -1200 {
lab=SW6n}
N 1850 -1200 1870 -1200 {
lab=SW6n}
N 1840 -1200 1850 -1200 {
lab=bit6}
N 1870 -930 1870 -760 {
lab=#net14}
N 1850 -770 1850 -760 {
lab=#net15}
N 1850 -550 1850 -530 {
lab=clk_6}
N 1870 -550 1870 -530 {
lab=#net16}
N 1820 -530 1850 -530 {
lab=clk_6}
N 1850 -410 1850 -390 {
lab=bit7}
N 1890 -410 1890 -390 {
lab=Vcmp}
N 1290 -810 1290 -790 {
lab=#net15}
N 1520 -970 1520 -950 {
lab=RESET}
N 1520 -950 1530 -950 {
lab=RESET}
N 1500 -970 1500 -930 {
lab=Vcmp}
N 1500 -930 1530 -930 {
lab=Vcmp}
N 1480 -970 1480 -930 {
lab=#net17}
N 1460 -810 1460 -790 {
lab=clk_4.7}
N 1500 -1180 1500 -1150 {
lab=SW4.7p}
N 1500 -1180 1510 -1180 {
lab=SW4.7p}
N 1480 -1200 1480 -1150 {
lab=SW4.7n}
N 1480 -1200 1510 -1200 {
lab=SW4.7n}
N 1460 -1200 1480 -1200 {
lab=SW4.7n}
N 1450 -1200 1460 -1200 {
lab=bit4.7}
N 1500 -810 1500 -790 {
lab=#net18}
N 2100 -970 2100 -950 {
lab=RESET}
N 2100 -950 2110 -950 {
lab=RESET}
N 2080 -970 2080 -930 {
lab=Vcmp}
N 2080 -930 2110 -930 {
lab=Vcmp}
N 2060 -970 2060 -930 {
lab=#net19}
N 2080 -1180 2080 -1150 {
lab=SW7p}
N 2080 -1180 2090 -1180 {
lab=SW7p}
N 2060 -1200 2060 -1150 {
lab=SW7n}
N 2060 -1200 2090 -1200 {
lab=SW7n}
N 2040 -1200 2060 -1200 {
lab=SW7n}
N 2030 -1200 2040 -1200 {
lab=bit7}
N 2060 -930 2060 -760 {
lab=#net19}
N 2040 -770 2040 -760 {
lab=#net18}
N 2040 -550 2040 -530 {
lab=clk_7}
N 2060 -550 2060 -530 {
lab=#net20}
N 2010 -530 2040 -530 {
lab=clk_7}
N 2040 -410 2040 -390 {
lab=bit8}
N 2080 -410 2080 -390 {
lab=Vcmp}
N 2040 -790 2040 -770 {
lab=#net18}
N 1080 -770 1660 -770 {
lab=#net12}
N 1290 -790 1290 -780 {
lab=#net15}
N 1290 -780 1850 -780 {
lab=#net15}
N 1850 -780 1850 -770 {
lab=#net15}
N 1500 -790 2040 -790 {
lab=#net18}
N 480 -790 480 -780 {
lab=#net7}
N 840 -780 840 -770 {
lab=#net7}
N 2310 -970 2310 -950 {
lab=RESET}
N 2310 -950 2320 -950 {
lab=RESET}
N 2290 -970 2290 -930 {
lab=Vcmp}
N 2290 -930 2320 -930 {
lab=Vcmp}
N 2270 -970 2270 -930 {
lab=#net21}
N 2250 -810 2250 -790 {
lab=clk_8.9}
N 2290 -1180 2290 -1150 {
lab=SW8.9p}
N 2290 -1180 2300 -1180 {
lab=SW8.9p}
N 2270 -1200 2270 -1150 {
lab=SW8.9n}
N 2270 -1200 2300 -1200 {
lab=SW8.9n}
N 2250 -1200 2270 -1200 {
lab=SW8.9n}
N 2240 -1200 2250 -1200 {
lab=bit8.9}
N 2520 -970 2520 -950 {
lab=RESET}
N 2520 -950 2530 -950 {
lab=RESET}
N 2500 -970 2500 -930 {
lab=Vcmp}
N 2500 -930 2530 -930 {
lab=Vcmp}
N 2480 -970 2480 -930 {
lab=#net22}
N 2460 -810 2460 -790 {
lab=clk_8.10}
N 2500 -1180 2500 -1150 {
lab=SW8.10p}
N 2500 -1180 2510 -1180 {
lab=SW8.10p}
N 2480 -1200 2480 -1150 {
lab=SW8.10n}
N 2480 -1200 2510 -1200 {
lab=SW8.10n}
N 2460 -1200 2480 -1200 {
lab=SW8.10n}
N 2450 -1200 2460 -1200 {
lab=bit8.10}
N 2930 -970 2930 -950 {
lab=RESET}
N 2930 -950 2940 -950 {
lab=RESET}
N 2910 -970 2910 -930 {
lab=Vcmp}
N 2910 -930 2940 -930 {
lab=Vcmp}
N 2890 -970 2890 -930 {
lab=#net23}
N 2910 -1180 2910 -1150 {
lab=SW9p}
N 2910 -1180 2920 -1180 {
lab=SW9p}
N 2890 -1200 2890 -1150 {
lab=SW9n}
N 2890 -1200 2920 -1200 {
lab=SW9n}
N 2870 -1200 2890 -1200 {
lab=SW9n}
N 2860 -1200 2870 -1200 {
lab=bit9}
N 2890 -930 2890 -760 {
lab=#net23}
N 2870 -770 2870 -760 {
lab=#net24}
N 2290 -810 2290 -770 {
lab=#net24}
N 2870 -550 2870 -530 {
lab=clk_9}
N 2890 -550 2890 -530 {
lab=#net25}
N 2840 -530 2870 -530 {
lab=clk_9}
N 2870 -410 2870 -390 {
lab=bit5}
N 2910 -410 2910 -390 {
lab=Vcmp}
N 3120 -970 3120 -950 {
lab=RESET}
N 3120 -950 3130 -950 {
lab=RESET}
N 3100 -970 3100 -930 {
lab=Vcmp}
N 3100 -930 3130 -930 {
lab=Vcmp}
N 3080 -970 3080 -930 {
lab=#net26}
N 3100 -1180 3100 -1150 {
lab=SW10p}
N 3100 -1180 3110 -1180 {
lab=SW10p}
N 3080 -1200 3080 -1150 {
lab=SW10n}
N 3080 -1200 3110 -1200 {
lab=SW10n}
N 3060 -1200 3080 -1200 {
lab=SW10n}
N 3050 -1200 3060 -1200 {
lab=bit10}
N 3080 -930 3080 -760 {
lab=#net26}
N 3060 -770 3060 -760 {
lab=#net27}
N 3060 -550 3060 -530 {
lab=clk_10}
N 3080 -550 3080 -530 {
lab=#net28}
N 3030 -530 3060 -530 {
lab=clk_10}
N 3060 -410 3060 -390 {
lab=bit7}
N 3100 -410 3100 -390 {
lab=Vcmp}
N 2500 -810 2500 -790 {
lab=#net27}
N 2730 -970 2730 -950 {
lab=RESET}
N 2730 -950 2740 -950 {
lab=RESET}
N 2710 -970 2710 -930 {
lab=Vcmp}
N 2710 -930 2740 -930 {
lab=Vcmp}
N 2690 -970 2690 -930 {
lab=#net29}
N 2670 -810 2670 -790 {
lab=clk_8.11}
N 2710 -1180 2710 -1150 {
lab=SW8.11p}
N 2710 -1180 2720 -1180 {
lab=SW8.11p}
N 2690 -1200 2690 -1150 {
lab=SW8.11n}
N 2690 -1200 2720 -1200 {
lab=SW8.11n}
N 2670 -1200 2690 -1200 {
lab=SW8.11n}
N 2660 -1200 2670 -1200 {
lab=bit8.11}
N 2710 -810 2710 -790 {
lab=#net30}
N 3310 -970 3310 -950 {
lab=RESET}
N 3310 -950 3320 -950 {
lab=RESET}
N 3290 -970 3290 -930 {
lab=Vcmp}
N 3290 -930 3320 -930 {
lab=Vcmp}
N 3270 -970 3270 -930 {
lab=#net31}
N 3290 -1180 3290 -1150 {
lab=SW11p}
N 3290 -1180 3300 -1180 {
lab=SW11p}
N 3270 -1200 3270 -1150 {
lab=SW11n}
N 3270 -1200 3300 -1200 {
lab=SW11n}
N 3250 -1200 3270 -1200 {
lab=SW11n}
N 3240 -1200 3250 -1200 {
lab=bit11}
N 3270 -930 3270 -760 {
lab=#net31}
N 3250 -770 3250 -760 {
lab=#net30}
N 3250 -550 3250 -530 {
lab=clk_11}
N 3270 -550 3270 -530 {
lab=#net32}
N 3220 -530 3250 -530 {
lab=clk_11}
N 3250 -410 3250 -390 {
lab=bit8}
N 3290 -410 3290 -390 {
lab=Vcmp}
N 3250 -790 3250 -770 {
lab=#net30}
N 2290 -770 2870 -770 {
lab=#net24}
N 2500 -790 2500 -780 {
lab=#net27}
N 2500 -780 3060 -780 {
lab=#net27}
N 3060 -780 3060 -770 {
lab=#net27}
N 2710 -790 3250 -790 {
lab=#net30}
N 3520 -970 3520 -950 {
lab=RESET}
N 3520 -950 3530 -950 {
lab=RESET}
N 3500 -970 3500 -930 {
lab=Vcmp}
N 3500 -930 3530 -930 {
lab=Vcmp}
N 3480 -970 3480 -930 {
lab=clk_12}
N 3500 -1180 3500 -1150 {
lab=SW12p}
N 3500 -1180 3510 -1180 {
lab=SW12p}
N 3480 -1200 3480 -1150 {
lab=SW12n}
N 3480 -1200 3510 -1200 {
lab=SW12n}
N 3460 -1200 3480 -1200 {
lab=SW12n}
N 3450 -1200 3460 -1200 {
lab=bit12}
N 3730 -970 3730 -950 {
lab=RESET}
N 3730 -950 3740 -950 {
lab=RESET}
N 3710 -970 3710 -930 {
lab=Vcmp}
N 3710 -930 3740 -930 {
lab=Vcmp}
N 3690 -970 3690 -930 {
lab=clk_13}
N 3690 -1200 3690 -1150 {
lab=bit13}
N 3670 -1200 3690 -1200 {
lab=bit13}
N 3660 -1200 3670 -1200 {
lab=bit13}
N 590 -1640 640 -1640 {
lab=#net33}
N 640 -1650 640 -1640 {
lab=#net33}
N 480 -1610 490 -1610 {
lab=clk_dump_bus}
N 480 -1610 480 -1570 {
lab=clk_dump_bus}
N 480 -1570 490 -1570 {
lab=clk_dump_bus}
N 470 -1550 490 -1550 {
lab=#net34}
N 730 -1610 740 -1610 {
lab=clk_dump_bus}
N 730 -1610 730 -1570 {
lab=clk_dump_bus}
N 730 -1570 740 -1570 {
lab=clk_dump_bus}
N 720 -1650 720 -1550 {
lab=#net35}
N 720 -1550 740 -1550 {
lab=#net35}
N 470 -1780 470 -1770 {
lab=#net33}
N 470 -1650 470 -1550 {
lab=#net34}
N 570 -1640 590 -1640 {
lab=#net33}
N 380 -1790 390 -1790 {
lab=bit1.2}
N 390 -1790 390 -1770 {
lab=bit1.2}
N 380 -1810 430 -1810 {
lab=bit2}
N 430 -1810 430 -1770 {
lab=bit2}
N 530 -1640 570 -1640 {}
N 530 -1780 530 -1640 {}
N 470 -1780 530 -1780 {}
N 630 -1790 640 -1790 {}
N 640 -1790 640 -1770 {}
N 630 -1810 680 -1810 {}
N 680 -1810 680 -1770 {}
N 840 -1640 890 -1640 {
lab=#net33}
N 890 -1650 890 -1640 {
lab=#net33}
N 720 -1780 720 -1770 {
lab=#net33}
N 820 -1640 840 -1640 {
lab=#net33}
N 780 -1640 820 -1640 {}
N 780 -1780 780 -1640 {}
N 720 -1780 780 -1780 {}
N 1090 -1640 1140 -1640 {
lab=#net33}
N 1140 -1650 1140 -1640 {
lab=#net33}
N 980 -1610 990 -1610 {
lab=clk_dump_bus}
N 980 -1610 980 -1570 {
lab=clk_dump_bus}
N 980 -1570 990 -1570 {
lab=clk_dump_bus}
N 970 -1550 990 -1550 {
lab=#net34}
N 1230 -1610 1240 -1610 {
lab=clk_dump_bus}
N 1230 -1610 1230 -1570 {
lab=clk_dump_bus}
N 1230 -1570 1240 -1570 {
lab=clk_dump_bus}
N 1220 -1650 1220 -1550 {
lab=#net35}
N 1220 -1550 1240 -1550 {
lab=#net35}
N 970 -1780 970 -1770 {
lab=#net33}
N 970 -1650 970 -1550 {
lab=#net34}
N 1070 -1640 1090 -1640 {
lab=#net33}
N 880 -1790 890 -1790 {
lab=bit1.2}
N 890 -1790 890 -1770 {
lab=bit1.2}
N 880 -1810 930 -1810 {
lab=bit2}
N 930 -1810 930 -1770 {
lab=bit2}
N 1030 -1640 1070 -1640 {}
N 1030 -1780 1030 -1640 {}
N 970 -1780 1030 -1780 {}
N 1130 -1790 1140 -1790 {}
N 1140 -1790 1140 -1770 {}
N 1130 -1810 1180 -1810 {}
N 1180 -1810 1180 -1770 {}
N 1340 -1640 1390 -1640 {
lab=#net33}
N 1390 -1650 1390 -1640 {
lab=#net33}
N 1220 -1780 1220 -1770 {
lab=#net33}
N 1320 -1640 1340 -1640 {
lab=#net33}
N 1280 -1640 1320 -1640 {}
N 1280 -1780 1280 -1640 {}
N 1220 -1780 1280 -1780 {}
N 1590 -1640 1640 -1640 {
lab=#net33}
N 1640 -1650 1640 -1640 {
lab=#net33}
N 1480 -1610 1490 -1610 {
lab=clk_dump_bus}
N 1480 -1610 1480 -1570 {
lab=clk_dump_bus}
N 1480 -1570 1490 -1570 {
lab=clk_dump_bus}
N 1470 -1550 1490 -1550 {
lab=#net34}
N 1730 -1610 1740 -1610 {
lab=clk_dump_bus}
N 1730 -1610 1730 -1570 {
lab=clk_dump_bus}
N 1730 -1570 1740 -1570 {
lab=clk_dump_bus}
N 1720 -1650 1720 -1550 {
lab=#net35}
N 1720 -1550 1740 -1550 {
lab=#net35}
N 1470 -1780 1470 -1770 {
lab=#net33}
N 1470 -1650 1470 -1550 {
lab=#net34}
N 1570 -1640 1590 -1640 {
lab=#net33}
N 1380 -1790 1390 -1790 {
lab=bit1.2}
N 1390 -1790 1390 -1770 {
lab=bit1.2}
N 1380 -1810 1430 -1810 {
lab=bit2}
N 1430 -1810 1430 -1770 {
lab=bit2}
N 1530 -1640 1570 -1640 {}
N 1530 -1780 1530 -1640 {}
N 1470 -1780 1530 -1780 {}
N 1630 -1790 1640 -1790 {}
N 1640 -1790 1640 -1770 {}
N 1630 -1810 1680 -1810 {}
N 1680 -1810 1680 -1770 {}
N 1840 -1640 1890 -1640 {
lab=#net33}
N 1890 -1650 1890 -1640 {
lab=#net33}
N 1720 -1780 1720 -1770 {
lab=#net33}
N 1820 -1640 1840 -1640 {
lab=#net33}
N 1780 -1640 1820 -1640 {}
N 1780 -1780 1780 -1640 {}
N 1720 -1780 1780 -1780 {}
N 2090 -1640 2140 -1640 {
lab=#net33}
N 2140 -1650 2140 -1640 {
lab=#net33}
N 1980 -1610 1990 -1610 {
lab=clk_dump_bus}
N 1980 -1610 1980 -1570 {
lab=clk_dump_bus}
N 1980 -1570 1990 -1570 {
lab=clk_dump_bus}
N 1970 -1550 1990 -1550 {
lab=#net34}
N 2230 -1610 2240 -1610 {
lab=clk_dump_bus}
N 2230 -1610 2230 -1570 {
lab=clk_dump_bus}
N 2230 -1570 2240 -1570 {
lab=clk_dump_bus}
N 2220 -1650 2220 -1550 {
lab=#net35}
N 2220 -1550 2240 -1550 {
lab=#net35}
N 1970 -1780 1970 -1770 {
lab=#net33}
N 1970 -1650 1970 -1550 {
lab=#net34}
N 2070 -1640 2090 -1640 {
lab=#net33}
N 1880 -1790 1890 -1790 {
lab=bit1.2}
N 1890 -1790 1890 -1770 {
lab=bit1.2}
N 1880 -1810 1930 -1810 {
lab=bit2}
N 1930 -1810 1930 -1770 {
lab=bit2}
N 2030 -1640 2070 -1640 {}
N 2030 -1780 2030 -1640 {}
N 1970 -1780 2030 -1780 {}
N 2130 -1790 2140 -1790 {}
N 2140 -1790 2140 -1770 {}
N 2130 -1810 2180 -1810 {}
N 2180 -1810 2180 -1770 {}
N 2220 -1780 2220 -1770 {
lab=#net33}
N 230 -1610 240 -1610 {
lab=clk_dump_bus}
N 230 -1610 230 -1570 {
lab=clk_dump_bus}
N 230 -1570 240 -1570 {
lab=clk_dump_bus}
N 220 -1550 240 -1550 {
lab=#net34}
N 390 -1650 390 -1640 {}
N 220 -1640 390 -1640 {}
N 220 -1640 220 -1550 {}
N 2480 -1610 2490 -1610 {
lab=clk_dump_bus}
N 2480 -1610 2480 -1570 {
lab=clk_dump_bus}
N 2480 -1570 2490 -1570 {
lab=clk_dump_bus}
N 2470 -1550 2490 -1550 {
lab=#net34}
N 2220 -1790 2230 -1790 {}
N 2220 -1790 2220 -1780 {}
N 2470 -1650 2470 -1550 {}
N 2460 -1650 2470 -1650 {}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Dr. Aubrey Beal, Dr. Phillip Bailey, Micah Tseng"}
C {sky130_stdcells/dfxtp_2.sym} 460 -170 0 0 {name=x2 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfxtp_2.sym} 260 -170 0 0 {name=x1 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 360 -220 0 0 {name=l2 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 660 -170 0 0 {name=x3 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 560 -220 0 0 {name=l3 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 360 -130 0 0 {name=l4 sig_type=std_logic lab=clk_1.2
}
C {devices/lab_pin.sym} 560 -130 0 0 {name=l5 sig_type=std_logic lab=clk_1.3
}
C {sky130_stdcells/dfxtp_2.sym} 860 -170 0 0 {name=x4 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 760 -220 0 0 {name=l6 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1060 -170 0 0 {name=x5 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 960 -220 0 0 {name=l7 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 760 -130 0 0 {name=l8 sig_type=std_logic lab=clk_2

}
C {devices/lab_pin.sym} 960 -130 0 0 {name=l9 sig_type=std_logic lab=clk_3
}
C {sky130_stdcells/dfxtp_2.sym} 1260 -170 0 0 {name=x6 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1160 -220 0 0 {name=l10 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1460 -170 0 0 {name=x7 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1360 -220 0 0 {name=l11 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1160 -130 0 0 {name=l12 sig_type=std_logic lab=clk_4.5
}
C {devices/lab_pin.sym} 1360 -130 0 0 {name=l13 sig_type=std_logic lab=clk_4.6
}
C {sky130_stdcells/dfxtp_2.sym} 1660 -170 0 0 {name=x8 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1560 -220 0 0 {name=l14 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1860 -170 0 0 {name=x9 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1760 -220 0 0 {name=l15 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1560 -130 0 0 {name=l16 sig_type=std_logic lab=clk_4.7
}
C {devices/lab_pin.sym} 1760 -130 0 0 {name=l17 sig_type=std_logic lab=clk_5
}
C {sky130_stdcells/dfxtp_2.sym} 2060 -170 0 0 {name=x10 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1960 -220 0 0 {name=l18 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 2260 -170 0 0 {name=x11 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2160 -220 0 0 {name=l19 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1960 -130 0 0 {name=l20 sig_type=std_logic lab=clk_6
}
C {devices/lab_pin.sym} 2160 -130 0 0 {name=l21 sig_type=std_logic lab=clk_7
}
C {sky130_stdcells/dfxtp_2.sym} 2460 -170 0 0 {name=x12 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2360 -220 0 0 {name=l22 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 2660 -170 0 0 {name=x13 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2560 -220 0 0 {name=l23 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2360 -130 0 0 {name=l24 sig_type=std_logic lab=clk_8.9
}
C {devices/lab_pin.sym} 2560 -130 0 0 {name=l25 sig_type=std_logic lab=clk_8.10
}
C {sky130_stdcells/dfxtp_2.sym} 2860 -170 0 0 {name=x14 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2760 -220 0 0 {name=l26 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 3060 -170 0 0 {name=x15 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2960 -220 0 0 {name=l27 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2760 -130 0 0 {name=l28 sig_type=std_logic lab=clk_8.11
}
C {devices/lab_pin.sym} 2960 -130 0 0 {name=l29 sig_type=std_logic lab=clk_9
}
C {sky130_stdcells/dfxtp_2.sym} 3260 -170 0 0 {name=x16 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3160 -220 0 0 {name=l30 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 3460 -170 0 0 {name=x17 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3360 -220 0 0 {name=l31 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3160 -130 0 0 {name=l32 sig_type=std_logic lab=clk_10
}
C {devices/lab_pin.sym} 3360 -130 0 0 {name=l33 sig_type=std_logic lab=clk_11
}
C {sky130_stdcells/dfxtp_2.sym} 3660 -170 0 0 {name=x18 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3560 -220 0 0 {name=l34 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 3860 -170 0 0 {name=x19 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3760 -220 0 0 {name=l35 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3560 -130 0 0 {name=l36 sig_type=std_logic lab=clk_12
}
C {devices/lab_pin.sym} 3760 -130 0 0 {name=l37 sig_type=std_logic lab=clk_13
}
C {devices/lab_pin.sym} 160 -220 0 0 {name=l38 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 160 -160 0 0 {name=l39 sig_type=std_logic lab=clk_pulse}
C {sky130_stdcells/dfxtp_2.sym} 4060 -170 0 0 {name=x20 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3960 -220 0 0 {name=l40 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3960 -130 0 0 {name=l41 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 4170 -180 2 0 {name=l42 sig_type=std_logic lab=RESET}
C {sky130_stdcells/dfrbp_1.sym} 270 -1060 3 0 {name=x21 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfsbp_1.sym} 690 -1060 3 0 {name=x22 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 250 -870 3 0 {name=x23 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 300 -930 2 0 {name=l43 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 300 -950 2 0 {name=l44 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 230 -790 0 0 {name=l45 sig_type=std_logic lab=clk_1.2
}
C {demux2.sym} 660 -650 1 1 {name=x24}
C {devices/lab_pin.sym} 280 -1180 2 0 {name=l46 sig_type=std_logic lab=SW1.2p
}
C {devices/lab_pin.sym} 280 -1200 2 0 {name=l47 sig_type=std_logic lab=SW1.2n}
C {devices/lab_pin.sym} 220 -1200 0 0 {name=l48 sig_type=std_logic lab=bit1.2}
C {sky130_stdcells/dfrbp_1.sym} 480 -1060 3 0 {name=x25 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 460 -870 3 0 {name=x26 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 510 -930 2 0 {name=l49 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 510 -950 2 0 {name=l50 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 440 -790 0 0 {name=l51 sig_type=std_logic lab=clk_1.3
}
C {devices/lab_pin.sym} 490 -1180 2 0 {name=l52 sig_type=std_logic lab=SW1.3p
}
C {devices/lab_pin.sym} 490 -1200 2 0 {name=l53 sig_type=std_logic lab=SW1.3n}
C {devices/lab_pin.sym} 430 -1200 0 0 {name=l54 sig_type=std_logic lab=bit1.3}
C {devices/lab_pin.sym} 720 -930 2 0 {name=l55 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 720 -950 2 0 {name=l56 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 620 -530 0 0 {name=l57 sig_type=std_logic lab=clk_2
}
C {devices/lab_pin.sym} 700 -1180 2 0 {name=l58 sig_type=std_logic lab=SW2p
}
C {devices/lab_pin.sym} 700 -1200 2 0 {name=l59 sig_type=std_logic lab=SW2n}
C {devices/lab_pin.sym} 640 -1200 0 0 {name=l60 sig_type=std_logic lab=bit2
}
C {sky130_stdcells/xor2_1.sym} 670 -470 3 0 {name=x29 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 650 -390 0 0 {name=l61 sig_type=std_logic lab=bit2
}
C {devices/lab_pin.sym} 690 -390 2 0 {name=l62 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfsbp_1.sym} 880 -1060 3 0 {name=x28 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 850 -650 1 1 {name=x30}
C {devices/lab_pin.sym} 910 -930 2 0 {name=l63 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 910 -950 2 0 {name=l64 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 810 -530 0 0 {name=l65 sig_type=std_logic lab=clk_3
}
C {devices/lab_pin.sym} 890 -1180 2 0 {name=l66 sig_type=std_logic lab=SW3p
}
C {devices/lab_pin.sym} 890 -1200 2 0 {name=l67 sig_type=std_logic lab=SW3n
}
C {devices/lab_pin.sym} 830 -1200 0 0 {name=l68 sig_type=std_logic lab=bit3
}
C {sky130_stdcells/xor2_1.sym} 860 -470 3 0 {name=x31 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 840 -390 0 0 {name=l69 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 880 -390 2 0 {name=l70 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 1080 -1060 3 0 {name=x27 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfsbp_1.sym} 1700 -1060 3 0 {name=x32 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 1060 -870 3 0 {name=x33 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1110 -930 2 0 {name=l71 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1110 -950 2 0 {name=l72 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1040 -790 0 0 {name=l73 sig_type=std_logic lab=clk_4.5
}
C {demux2.sym} 1670 -650 1 1 {name=x34}
C {devices/lab_pin.sym} 1090 -1180 2 0 {name=l74 sig_type=std_logic lab=SW4.5p
}
C {devices/lab_pin.sym} 1090 -1200 2 0 {name=l75 sig_type=std_logic lab=SW4.5n
}
C {devices/lab_pin.sym} 1030 -1200 0 0 {name=l76 sig_type=std_logic lab=bit4.5
}
C {sky130_stdcells/dfrbp_1.sym} 1290 -1060 3 0 {name=x35 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 1270 -870 3 0 {name=x36 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1320 -930 2 0 {name=l77 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1320 -950 2 0 {name=l78 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1250 -790 0 0 {name=l79 sig_type=std_logic lab=clk_4.6
}
C {devices/lab_pin.sym} 1300 -1180 2 0 {name=l80 sig_type=std_logic lab=SW4.6p
}
C {devices/lab_pin.sym} 1300 -1200 2 0 {name=l81 sig_type=std_logic lab=SW4.6n
}
C {devices/lab_pin.sym} 1240 -1200 0 0 {name=l82 sig_type=std_logic lab=bit4.6
}
C {devices/lab_pin.sym} 1730 -930 2 0 {name=l83 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1730 -950 2 0 {name=l84 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1630 -530 0 0 {name=l85 sig_type=std_logic lab=clk_5
}
C {devices/lab_pin.sym} 1710 -1180 2 0 {name=l86 sig_type=std_logic lab=SW5p
}
C {devices/lab_pin.sym} 1710 -1200 2 0 {name=l87 sig_type=std_logic lab=SW5n
}
C {devices/lab_pin.sym} 1650 -1200 0 0 {name=l88 sig_type=std_logic lab=bit5
}
C {sky130_stdcells/xor2_1.sym} 1680 -470 3 0 {name=x37 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1660 -390 0 0 {name=l89 sig_type=std_logic lab=bit5
}
C {devices/lab_pin.sym} 1700 -390 2 0 {name=l90 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfsbp_1.sym} 1890 -1060 3 0 {name=x38 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 1860 -650 1 1 {name=x39}
C {devices/lab_pin.sym} 1920 -930 2 0 {name=l91 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1920 -950 2 0 {name=l92 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1820 -530 0 0 {name=l93 sig_type=std_logic lab=clk_6
}
C {devices/lab_pin.sym} 1900 -1180 2 0 {name=l94 sig_type=std_logic lab=SW6p
}
C {devices/lab_pin.sym} 1900 -1200 2 0 {name=l95 sig_type=std_logic lab=SW6n
}
C {devices/lab_pin.sym} 1840 -1200 0 0 {name=l96 sig_type=std_logic lab=bit6
}
C {sky130_stdcells/xor2_1.sym} 1870 -470 3 0 {name=x40 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1850 -390 0 0 {name=l97 sig_type=std_logic lab=bit7
}
C {devices/lab_pin.sym} 1890 -390 2 0 {name=l98 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 1500 -1060 3 0 {name=x41 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 1480 -870 3 0 {name=x42 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1530 -930 2 0 {name=l99 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1530 -950 2 0 {name=l100 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1460 -790 0 0 {name=l101 sig_type=std_logic lab=clk_4.7
}
C {devices/lab_pin.sym} 1510 -1180 2 0 {name=l102 sig_type=std_logic lab=SW4.7p
}
C {devices/lab_pin.sym} 1510 -1200 2 0 {name=l103 sig_type=std_logic lab=SW4.7n
}
C {devices/lab_pin.sym} 1450 -1200 0 0 {name=l104 sig_type=std_logic lab=bit4.7
}
C {sky130_stdcells/dfsbp_1.sym} 2080 -1060 3 0 {name=x43 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 2050 -650 1 1 {name=x44}
C {devices/lab_pin.sym} 2110 -930 2 0 {name=l105 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2110 -950 2 0 {name=l106 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2010 -530 0 0 {name=l107 sig_type=std_logic lab=clk_7
}
C {devices/lab_pin.sym} 2090 -1180 2 0 {name=l108 sig_type=std_logic lab=SW7p
}
C {devices/lab_pin.sym} 2090 -1200 2 0 {name=l109 sig_type=std_logic lab=SW7n
}
C {devices/lab_pin.sym} 2030 -1200 0 0 {name=l110 sig_type=std_logic lab=bit7
}
C {sky130_stdcells/xor2_1.sym} 2060 -470 3 0 {name=x45 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2040 -390 0 0 {name=l111 sig_type=std_logic lab=bit8
}
C {devices/lab_pin.sym} 2080 -390 2 0 {name=l112 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 2290 -1060 3 0 {name=x46 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfsbp_1.sym} 2910 -1060 3 0 {name=x47 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 2270 -870 3 0 {name=x48 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2320 -930 2 0 {name=l113 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2320 -950 2 0 {name=l114 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2250 -790 0 0 {name=l115 sig_type=std_logic lab=clk_8.9
}
C {demux2.sym} 2880 -650 1 1 {name=x49}
C {devices/lab_pin.sym} 2300 -1180 2 0 {name=l116 sig_type=std_logic lab=SW8.9p
}
C {devices/lab_pin.sym} 2300 -1200 2 0 {name=l117 sig_type=std_logic lab=SW8.9n
}
C {devices/lab_pin.sym} 2240 -1200 0 0 {name=l118 sig_type=std_logic lab=bit8.9
}
C {sky130_stdcells/dfrbp_1.sym} 2500 -1060 3 0 {name=x50 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 2480 -870 3 0 {name=x51 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2530 -930 2 0 {name=l119 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2530 -950 2 0 {name=l120 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2460 -790 0 0 {name=l121 sig_type=std_logic lab=clk_8.10
}
C {devices/lab_pin.sym} 2510 -1180 2 0 {name=l122 sig_type=std_logic lab=SW8.10p
}
C {devices/lab_pin.sym} 2510 -1200 2 0 {name=l123 sig_type=std_logic lab=SW8.10n
}
C {devices/lab_pin.sym} 2450 -1200 0 0 {name=l124 sig_type=std_logic lab=bit8.10
}
C {devices/lab_pin.sym} 2940 -930 2 0 {name=l125 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2940 -950 2 0 {name=l126 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2840 -530 0 0 {name=l127 sig_type=std_logic lab=clk_9
}
C {devices/lab_pin.sym} 2920 -1180 2 0 {name=l128 sig_type=std_logic lab=SW9p
}
C {devices/lab_pin.sym} 2920 -1200 2 0 {name=l129 sig_type=std_logic lab=SW9n
}
C {devices/lab_pin.sym} 2860 -1200 0 0 {name=l130 sig_type=std_logic lab=bit9
}
C {sky130_stdcells/xor2_1.sym} 2890 -470 3 0 {name=x52 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2870 -390 0 0 {name=l131 sig_type=std_logic lab=bit5
}
C {devices/lab_pin.sym} 2910 -390 2 0 {name=l132 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfsbp_1.sym} 3100 -1060 3 0 {name=x53 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 3070 -650 1 1 {name=x54}
C {devices/lab_pin.sym} 3130 -930 2 0 {name=l133 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 3130 -950 2 0 {name=l134 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 3030 -530 0 0 {name=l135 sig_type=std_logic lab=clk_10
}
C {devices/lab_pin.sym} 3110 -1180 2 0 {name=l136 sig_type=std_logic lab=SW10p
}
C {devices/lab_pin.sym} 3110 -1200 2 0 {name=l137 sig_type=std_logic lab=SW10n
}
C {devices/lab_pin.sym} 3050 -1200 0 0 {name=l138 sig_type=std_logic lab=bit10
}
C {sky130_stdcells/xor2_1.sym} 3080 -470 3 0 {name=x55 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3060 -390 0 0 {name=l139 sig_type=std_logic lab=bit7
}
C {devices/lab_pin.sym} 3100 -390 2 0 {name=l140 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 2710 -1060 3 0 {name=x56 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 2690 -870 3 0 {name=x57 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2740 -930 2 0 {name=l141 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2740 -950 2 0 {name=l142 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2670 -790 0 0 {name=l143 sig_type=std_logic lab=clk_8.11
}
C {devices/lab_pin.sym} 2720 -1180 2 0 {name=l144 sig_type=std_logic lab=SW8.11p
}
C {devices/lab_pin.sym} 2720 -1200 2 0 {name=l145 sig_type=std_logic lab=SW8.11n
}
C {devices/lab_pin.sym} 2660 -1200 0 0 {name=l146 sig_type=std_logic lab=bit8.11
}
C {sky130_stdcells/dfsbp_1.sym} 3290 -1060 3 0 {name=x58 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 3260 -650 1 1 {name=x59}
C {devices/lab_pin.sym} 3320 -930 2 0 {name=l147 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 3320 -950 2 0 {name=l148 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 3220 -530 0 0 {name=l149 sig_type=std_logic lab=clk_11
}
C {devices/lab_pin.sym} 3300 -1180 2 0 {name=l150 sig_type=std_logic lab=SW11p
}
C {devices/lab_pin.sym} 3300 -1200 2 0 {name=l151 sig_type=std_logic lab=SW11n
}
C {devices/lab_pin.sym} 3240 -1200 0 0 {name=l152 sig_type=std_logic lab=bit11
}
C {sky130_stdcells/xor2_1.sym} 3270 -470 3 0 {name=x60 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3250 -390 0 0 {name=l153 sig_type=std_logic lab=bit8
}
C {devices/lab_pin.sym} 3290 -390 2 0 {name=l154 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 3500 -1060 3 0 {name=x61 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3530 -930 2 0 {name=l155 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 3530 -950 2 0 {name=l156 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 3480 -930 0 0 {name=l157 sig_type=std_logic lab=clk_12
}
C {devices/lab_pin.sym} 3510 -1180 2 0 {name=l158 sig_type=std_logic lab=SW12p
}
C {devices/lab_pin.sym} 3510 -1200 2 0 {name=l159 sig_type=std_logic lab=SW12n
}
C {devices/lab_pin.sym} 3450 -1200 0 0 {name=l160 sig_type=std_logic lab=bit12
}
C {devices/lab_pin.sym} 3740 -930 2 0 {name=l161 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 3740 -950 2 0 {name=l162 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 3690 -930 0 0 {name=l163 sig_type=std_logic lab=clk_13
}
C {devices/lab_pin.sym} 3660 -1200 0 0 {name=l166 sig_type=std_logic lab=bit13
}
C {sky130_stdcells/dfrtp_1.sym} 3710 -1060 3 0 {name=x63 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 430 -1710 3 1 {name=x62 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 680 -1710 3 1 {name=x64 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfxtp_2.sym} 260 -170 0 0 {name=x66 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 580 -1550 0 0 {name=x67 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 830 -1550 0 0 {name=x68 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 490 -1610 2 0 {name=l164 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 670 -1570 2 0 {name=l165 sig_type=std_logic lab=D2
}
C {devices/lab_pin.sym} 740 -1610 2 0 {name=l167 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 380 -1790 0 0 {name=l168 sig_type=std_logic lab=bit1.2
}
C {devices/lab_pin.sym} 380 -1810 0 0 {name=l169 sig_type=std_logic lab=bit2
}
C {devices/lab_pin.sym} 630 -1810 0 0 {name=l170 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 630 -1790 0 0 {name=l171 sig_type=std_logic lab=bit1.3
}
C {devices/lab_pin.sym} 920 -1570 2 0 {name=l172 sig_type=std_logic lab=D3
}
C {devices/lab_pin.sym} 490 -1530 0 0 {name=l173 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 740 -1530 0 0 {name=l174 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/fa_1.sym} 930 -1710 3 1 {name=x65 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 1180 -1710 3 1 {name=x69 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 1080 -1550 0 0 {name=x70 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 1330 -1550 0 0 {name=x71 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 990 -1610 2 0 {name=l175 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 1170 -1570 2 0 {name=l176 sig_type=std_logic lab=D4
}
C {devices/lab_pin.sym} 1240 -1610 2 0 {name=l177 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 880 -1790 0 0 {name=l178 sig_type=std_logic lab=bit4.5
}
C {devices/lab_pin.sym} 880 -1810 0 0 {name=l179 sig_type=std_logic lab=bit5
}
C {devices/lab_pin.sym} 1130 -1810 0 0 {name=l180 sig_type=std_logic lab=bit6
}
C {devices/lab_pin.sym} 1130 -1790 0 0 {name=l181 sig_type=std_logic lab=bit4.6
}
C {devices/lab_pin.sym} 1420 -1570 2 0 {name=l182 sig_type=std_logic lab=D5
}
C {devices/lab_pin.sym} 990 -1530 0 0 {name=l183 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 1240 -1530 0 0 {name=l184 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/fa_1.sym} 1430 -1710 3 1 {name=x72 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 1680 -1710 3 1 {name=x73 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 1580 -1550 0 0 {name=x74 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 1830 -1550 0 0 {name=x75 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1490 -1610 2 0 {name=l185 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 1670 -1570 2 0 {name=l186 sig_type=std_logic lab=D6
}
C {devices/lab_pin.sym} 1740 -1610 2 0 {name=l187 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 1380 -1790 0 0 {name=l188 sig_type=std_logic lab=bit4.7
}
C {devices/lab_pin.sym} 1380 -1810 0 0 {name=l189 sig_type=std_logic lab=bit7
}
C {devices/lab_pin.sym} 1630 -1810 0 0 {name=l190 sig_type=std_logic lab=bit9
}
C {devices/lab_pin.sym} 1630 -1790 0 0 {name=l191 sig_type=std_logic lab=bit8.9
}
C {devices/lab_pin.sym} 1920 -1570 2 0 {name=l192 sig_type=std_logic lab=D7
}
C {devices/lab_pin.sym} 1490 -1530 0 0 {name=l193 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 1740 -1530 0 0 {name=l194 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/fa_1.sym} 1930 -1710 3 1 {name=x76 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 2180 -1710 3 1 {name=x77 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 2080 -1550 0 0 {name=x78 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 2330 -1550 0 0 {name=x79 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1990 -1610 2 0 {name=l195 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 2170 -1570 2 0 {name=l196 sig_type=std_logic lab=D8
}
C {devices/lab_pin.sym} 2240 -1610 2 0 {name=l197 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 1880 -1790 0 0 {name=l198 sig_type=std_logic lab=bit8.10
}
C {devices/lab_pin.sym} 1880 -1810 0 0 {name=l199 sig_type=std_logic lab=bit10
}
C {devices/lab_pin.sym} 2130 -1810 0 0 {name=l200 sig_type=std_logic lab=bit11
}
C {devices/lab_pin.sym} 2130 -1790 0 0 {name=l201 sig_type=std_logic lab=bit8.11
}
C {devices/lab_pin.sym} 2420 -1570 2 0 {name=l202 sig_type=std_logic lab=D9
}
C {devices/lab_pin.sym} 1990 -1530 0 0 {name=l203 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 2240 -1530 0 0 {name=l204 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/dfrtp_1.sym} 330 -1550 0 0 {name=x80 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 240 -1610 2 0 {name=l205 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 420 -1570 2 0 {name=l206 sig_type=std_logic lab=D1
}
C {devices/lab_pin.sym} 240 -1530 0 0 {name=l207 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/dfrtp_1.sym} 2580 -1550 0 0 {name=x81 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2490 -1610 2 0 {name=l208 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 2670 -1570 2 0 {name=l209 sig_type=std_logic lab=D10
}
C {devices/lab_pin.sym} 2490 -1530 0 0 {name=l210 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 2230 -1790 2 0 {name=l211 sig_type=std_logic lab=bit12
}
C {devices/lab_pin.sym} 2460 -1650 0 0 {name=l212 sig_type=std_logic lab=bit13
}
C {devices/lab_pin.sym} 280 -1460 0 0 {name=l213 sig_type=std_logic lab=clk_dump_bus
}
C {sky130_stdcells/inv_1.sym} 320 -1460 0 0 {name=x82 VGND=GND VNB=GND VPB=VCC VPWR=VCC prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 360 -1460 2 0 {name=l214 sig_type=std_logic lab=done
}
C {devices/code.sym} 60 -550 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false}
C {devices/code.sym} 210 -550 0 0 {name=STIMULI 
only_toplevel=true
value="
.options acct list
.temp 25
vvcc VCC 0 dc 1.8
*vvss GND 0 0
.control
tran 0.1u 400u
* plot a b+2 clk+4 reset_b+6 x+8 y+10 q+12 qlatch+14
plot RST_PLS-2 clk clk2+2 clk4+4 clk8+6 clk16+8 clk32+10 clk64+12 delayed+14 pulse+16
write pulse_generator.raw
.endc
"}
