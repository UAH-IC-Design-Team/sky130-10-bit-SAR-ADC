v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {Clock Pulse Delay Line
} 110 -940 0 0 0.4 0.4 {}
T {Bit Calculations with CRS} 140 -1860 0 0 0.4 0.4 {}
T {Digital Error Correction with parallel output bus
} 140 -2450 0 0 0.4 0.4 {}
N 350 -810 350 -790 {
lab=clk_1.2}
N 350 -790 370 -790 {
lab=clk_1.2}
N 360 -850 370 -850 {
lab=clk}
N 370 -850 370 -810 {
lab=clk}
N 550 -810 550 -790 {
lab=clk_1.3}
N 550 -790 570 -790 {
lab=clk_1.3}
N 560 -850 570 -850 {
lab=clk}
N 570 -850 570 -810 {
lab=clk}
N 360 -790 360 -760 {
lab=clk_1.2}
N 560 -790 560 -760 {
lab=clk_1.3}
N 750 -810 750 -790 {
lab=clk_2}
N 750 -790 770 -790 {
lab=clk_2}
N 760 -850 770 -850 {
lab=clk}
N 770 -850 770 -810 {
lab=clk}
N 950 -810 950 -790 {
lab=clk_3}
N 950 -790 970 -790 {
lab=clk_3}
N 960 -850 970 -850 {
lab=clk}
N 970 -850 970 -810 {
lab=clk}
N 760 -790 760 -760 {
lab=clk_2}
N 960 -790 960 -760 {
lab=clk_3}
N 1150 -810 1150 -790 {
lab=clk_4.5}
N 1150 -790 1170 -790 {
lab=clk_4.5}
N 1160 -850 1170 -850 {
lab=clk}
N 1170 -850 1170 -810 {
lab=clk}
N 1350 -810 1350 -790 {
lab=clk_4.6}
N 1350 -790 1370 -790 {
lab=clk_4.6}
N 1360 -850 1370 -850 {
lab=clk}
N 1370 -850 1370 -810 {
lab=clk}
N 1160 -790 1160 -760 {
lab=clk_4.5}
N 1360 -790 1360 -760 {
lab=clk_4.6}
N 1550 -810 1550 -790 {
lab=clk_4.7}
N 1550 -790 1570 -790 {
lab=clk_4.7}
N 1560 -850 1570 -850 {
lab=clk}
N 1570 -850 1570 -810 {
lab=clk}
N 1750 -810 1750 -790 {
lab=clk_5}
N 1750 -790 1770 -790 {
lab=clk_5}
N 1760 -850 1770 -850 {
lab=clk}
N 1770 -850 1770 -810 {
lab=clk}
N 1560 -790 1560 -760 {
lab=clk_4.7}
N 1760 -790 1760 -760 {
lab=clk_5}
N 1950 -810 1950 -790 {
lab=clk_6}
N 1950 -790 1970 -790 {
lab=clk_6}
N 1960 -850 1970 -850 {
lab=clk}
N 1970 -850 1970 -810 {
lab=clk}
N 2150 -810 2150 -790 {
lab=clk_7}
N 2150 -790 2170 -790 {
lab=clk_7}
N 2160 -850 2170 -850 {
lab=clk}
N 2170 -850 2170 -810 {
lab=clk}
N 1960 -790 1960 -760 {
lab=clk_6}
N 2160 -790 2160 -760 {
lab=clk_7}
N 2350 -810 2350 -790 {
lab=clk_8.9}
N 2350 -790 2370 -790 {
lab=clk_8.9}
N 2360 -850 2370 -850 {
lab=clk}
N 2370 -850 2370 -810 {
lab=clk}
N 2550 -810 2550 -790 {
lab=clk_8.10}
N 2550 -790 2570 -790 {
lab=clk_8.10}
N 2560 -850 2570 -850 {
lab=clk}
N 2570 -850 2570 -810 {
lab=clk}
N 2360 -790 2360 -760 {
lab=clk_8.9}
N 2560 -790 2560 -760 {
lab=clk_8.10}
N 2750 -810 2750 -790 {
lab=clk_8.11}
N 2750 -790 2770 -790 {
lab=clk_8.11}
N 2760 -850 2770 -850 {
lab=clk}
N 2770 -850 2770 -810 {
lab=clk}
N 2950 -810 2950 -790 {
lab=clk_9}
N 2950 -790 2970 -790 {
lab=clk_9}
N 2960 -850 2970 -850 {
lab=clk}
N 2970 -850 2970 -810 {
lab=clk}
N 2760 -790 2760 -760 {
lab=clk_8.11}
N 2960 -790 2960 -760 {
lab=clk_9}
N 3150 -810 3150 -790 {
lab=clk_10}
N 3150 -790 3170 -790 {
lab=clk_10}
N 3160 -850 3170 -850 {
lab=clk}
N 3170 -850 3170 -810 {
lab=clk}
N 3350 -810 3350 -790 {
lab=clk_11}
N 3350 -790 3370 -790 {
lab=clk_11}
N 3360 -850 3370 -850 {
lab=clk}
N 3370 -850 3370 -810 {
lab=clk}
N 3160 -790 3160 -760 {
lab=clk_10}
N 3360 -790 3360 -760 {
lab=clk_11}
N 3550 -810 3550 -790 {
lab=clk_12}
N 3550 -790 3570 -790 {
lab=clk_12}
N 3560 -850 3570 -850 {
lab=clk}
N 3570 -850 3570 -810 {
lab=clk}
N 3750 -810 3750 -790 {
lab=clk_13}
N 3750 -790 3770 -790 {
lab=clk_13}
N 3760 -850 3770 -850 {
lab=clk}
N 3770 -850 3770 -810 {
lab=clk}
N 3560 -790 3560 -760 {
lab=clk_12}
N 3760 -790 3760 -760 {
lab=clk_13}
N 160 -850 170 -850 {
lab=clk}
N 170 -850 170 -810 {
lab=clk}
N 160 -790 170 -790 {
lab=clk_pulse}
N 3950 -810 3950 -790 {
lab=clk_dump_bus}
N 3950 -790 3970 -790 {
lab=clk_dump_bus}
N 3960 -850 3970 -850 {
lab=clk}
N 3970 -850 3970 -810 {
lab=clk}
N 3960 -790 3960 -760 {
lab=clk_dump_bus}
N 4150 -810 4170 -810 {
lab=RESET}
N 310 -1540 310 -1520 {
lab=RESET}
N 310 -1520 320 -1520 {
lab=RESET}
N 290 -1540 290 -1500 {
lab=Vcmp}
N 290 -1500 320 -1500 {
lab=Vcmp}
N 270 -1540 270 -1500 {
lab=#net1}
N 250 -1380 250 -1360 {
lab=clk_1.2}
N 290 -1750 290 -1720 {
lab=SW1.2p}
N 290 -1750 300 -1750 {
lab=SW1.2p}
N 270 -1770 270 -1720 {
lab=SW1.2n}
N 270 -1770 300 -1770 {
lab=SW1.2n}
N 250 -1770 270 -1770 {
lab=SW1.2n}
N 240 -1770 250 -1770 {
lab=bit1.2}
N 520 -1540 520 -1520 {
lab=RESET}
N 520 -1520 530 -1520 {
lab=RESET}
N 500 -1540 500 -1500 {
lab=Vcmp}
N 500 -1500 530 -1500 {
lab=Vcmp}
N 480 -1540 480 -1500 {
lab=#net2}
N 460 -1380 460 -1360 {
lab=clk_1.3}
N 500 -1750 500 -1720 {
lab=SW1.3p}
N 500 -1750 510 -1750 {
lab=SW1.3p}
N 480 -1770 480 -1720 {
lab=SW1.3n}
N 480 -1770 510 -1770 {
lab=SW1.3n}
N 460 -1770 480 -1770 {
lab=SW1.3n}
N 450 -1770 460 -1770 {
lab=bit1.3}
N 730 -1540 730 -1520 {
lab=RESET}
N 730 -1520 740 -1520 {
lab=RESET}
N 710 -1540 710 -1500 {
lab=Vcmp}
N 710 -1500 740 -1500 {
lab=Vcmp}
N 690 -1540 690 -1500 {
lab=#net3}
N 710 -1750 710 -1720 {
lab=SW2p}
N 710 -1750 720 -1750 {
lab=SW2p}
N 690 -1770 690 -1720 {
lab=SW2n}
N 690 -1770 720 -1770 {
lab=SW2n}
N 670 -1770 690 -1770 {
lab=SW2n}
N 660 -1770 670 -1770 {
lab=bit2}
N 690 -1500 690 -1330 {
lab=#net3}
N 670 -1340 670 -1330 {
lab=#net4}
N 290 -1340 670 -1340 {
lab=#net4}
N 290 -1380 290 -1340 {
lab=#net4}
N 670 -1120 670 -1100 {
lab=clk_2}
N 690 -1120 690 -1100 {
lab=#net5}
N 640 -1100 670 -1100 {
lab=clk_2}
N 670 -980 670 -960 {
lab=bit2}
N 710 -980 710 -960 {
lab=Vcmp}
N 920 -1540 920 -1520 {
lab=RESET}
N 920 -1520 930 -1520 {
lab=RESET}
N 900 -1540 900 -1500 {
lab=Vcmp}
N 900 -1500 930 -1500 {
lab=Vcmp}
N 880 -1540 880 -1500 {
lab=#net6}
N 900 -1750 900 -1720 {
lab=SW3p}
N 900 -1750 910 -1750 {
lab=SW3p}
N 880 -1770 880 -1720 {
lab=SW3n}
N 880 -1770 910 -1770 {
lab=SW3n}
N 860 -1770 880 -1770 {
lab=SW3n}
N 850 -1770 860 -1770 {
lab=bit3}
N 880 -1500 880 -1330 {
lab=#net6}
N 860 -1340 860 -1330 {
lab=#net7}
N 860 -1120 860 -1100 {
lab=clk_3}
N 880 -1120 880 -1100 {
lab=#net8}
N 830 -1100 860 -1100 {
lab=clk_3}
N 860 -980 860 -960 {
lab=bit3}
N 900 -980 900 -960 {
lab=Vcmp}
N 500 -1350 860 -1350 {
lab=#net7}
N 500 -1380 500 -1360 {
lab=#net7}
N 1120 -1540 1120 -1520 {
lab=RESET}
N 1120 -1520 1130 -1520 {
lab=RESET}
N 1100 -1540 1100 -1500 {
lab=Vcmp}
N 1100 -1500 1130 -1500 {
lab=Vcmp}
N 1080 -1540 1080 -1500 {
lab=#net9}
N 1060 -1380 1060 -1360 {
lab=clk_4.5}
N 1100 -1750 1100 -1720 {
lab=SW4.5p}
N 1100 -1750 1110 -1750 {
lab=SW4.5p}
N 1080 -1770 1080 -1720 {
lab=SW4.5n}
N 1080 -1770 1110 -1770 {
lab=SW4.5n}
N 1060 -1770 1080 -1770 {
lab=SW4.5n}
N 1050 -1770 1060 -1770 {
lab=bit4.5}
N 1330 -1540 1330 -1520 {
lab=RESET}
N 1330 -1520 1340 -1520 {
lab=RESET}
N 1310 -1540 1310 -1500 {
lab=Vcmp}
N 1310 -1500 1340 -1500 {
lab=Vcmp}
N 1290 -1540 1290 -1500 {
lab=#net10}
N 1270 -1380 1270 -1360 {
lab=clk_4.6}
N 1310 -1750 1310 -1720 {
lab=SW4.6p}
N 1310 -1750 1320 -1750 {
lab=SW4.6p}
N 1290 -1770 1290 -1720 {
lab=SW4.6n}
N 1290 -1770 1320 -1770 {
lab=SW4.6n}
N 1270 -1770 1290 -1770 {
lab=SW4.6n}
N 1260 -1770 1270 -1770 {
lab=bit4.6}
N 1740 -1540 1740 -1520 {
lab=RESET}
N 1740 -1520 1750 -1520 {
lab=RESET}
N 1720 -1540 1720 -1500 {
lab=Vcmp}
N 1720 -1500 1750 -1500 {
lab=Vcmp}
N 1700 -1540 1700 -1500 {
lab=#net11}
N 1720 -1750 1720 -1720 {
lab=SW5p}
N 1720 -1750 1730 -1750 {
lab=SW5p}
N 1700 -1770 1700 -1720 {
lab=SW5n}
N 1700 -1770 1730 -1770 {
lab=SW5n}
N 1680 -1770 1700 -1770 {
lab=SW5n}
N 1670 -1770 1680 -1770 {
lab=bit5}
N 1700 -1500 1700 -1330 {
lab=#net11}
N 1680 -1340 1680 -1330 {
lab=#net12}
N 1100 -1380 1100 -1340 {
lab=#net12}
N 1680 -1120 1680 -1100 {
lab=clk_5}
N 1700 -1120 1700 -1100 {
lab=#net13}
N 1650 -1100 1680 -1100 {
lab=clk_5}
N 1680 -980 1680 -960 {
lab=bit5}
N 1720 -980 1720 -960 {
lab=Vcmp}
N 1930 -1540 1930 -1520 {
lab=RESET}
N 1930 -1520 1940 -1520 {
lab=RESET}
N 1910 -1540 1910 -1500 {
lab=Vcmp}
N 1910 -1500 1940 -1500 {
lab=Vcmp}
N 1890 -1540 1890 -1500 {
lab=#net14}
N 1910 -1750 1910 -1720 {
lab=SW6p}
N 1910 -1750 1920 -1750 {
lab=SW6p}
N 1890 -1770 1890 -1720 {
lab=SW6n}
N 1890 -1770 1920 -1770 {
lab=SW6n}
N 1870 -1770 1890 -1770 {
lab=SW6n}
N 1860 -1770 1870 -1770 {
lab=bit6}
N 1890 -1500 1890 -1330 {
lab=#net14}
N 1870 -1340 1870 -1330 {
lab=#net15}
N 1870 -1120 1870 -1100 {
lab=clk_6}
N 1890 -1120 1890 -1100 {
lab=#net16}
N 1840 -1100 1870 -1100 {
lab=clk_6}
N 1870 -980 1870 -960 {
lab=bit7}
N 1910 -980 1910 -960 {
lab=Vcmp}
N 1310 -1380 1310 -1360 {
lab=#net15}
N 1540 -1540 1540 -1520 {
lab=RESET}
N 1540 -1520 1550 -1520 {
lab=RESET}
N 1520 -1540 1520 -1500 {
lab=Vcmp}
N 1520 -1500 1550 -1500 {
lab=Vcmp}
N 1500 -1540 1500 -1500 {
lab=#net17}
N 1480 -1380 1480 -1360 {
lab=clk_4.7}
N 1520 -1750 1520 -1720 {
lab=SW4.7p}
N 1520 -1750 1530 -1750 {
lab=SW4.7p}
N 1500 -1770 1500 -1720 {
lab=SW4.7n}
N 1500 -1770 1530 -1770 {
lab=SW4.7n}
N 1480 -1770 1500 -1770 {
lab=SW4.7n}
N 1470 -1770 1480 -1770 {
lab=bit4.7}
N 1520 -1380 1520 -1360 {
lab=#net18}
N 2120 -1540 2120 -1520 {
lab=RESET}
N 2120 -1520 2130 -1520 {
lab=RESET}
N 2100 -1540 2100 -1500 {
lab=Vcmp}
N 2100 -1500 2130 -1500 {
lab=Vcmp}
N 2080 -1540 2080 -1500 {
lab=#net19}
N 2100 -1750 2100 -1720 {
lab=SW7p}
N 2100 -1750 2110 -1750 {
lab=SW7p}
N 2080 -1770 2080 -1720 {
lab=SW7n}
N 2080 -1770 2110 -1770 {
lab=SW7n}
N 2060 -1770 2080 -1770 {
lab=SW7n}
N 2050 -1770 2060 -1770 {
lab=bit7}
N 2080 -1500 2080 -1330 {
lab=#net19}
N 2060 -1340 2060 -1330 {
lab=#net18}
N 2060 -1120 2060 -1100 {
lab=clk_7}
N 2080 -1120 2080 -1100 {
lab=#net20}
N 2030 -1100 2060 -1100 {
lab=clk_7}
N 2060 -980 2060 -960 {
lab=bit8}
N 2100 -980 2100 -960 {
lab=Vcmp}
N 2060 -1360 2060 -1340 {
lab=#net18}
N 1100 -1340 1680 -1340 {
lab=#net12}
N 1310 -1360 1310 -1350 {
lab=#net15}
N 1310 -1350 1870 -1350 {
lab=#net15}
N 1870 -1350 1870 -1340 {
lab=#net15}
N 1520 -1360 2060 -1360 {
lab=#net18}
N 500 -1360 500 -1350 {
lab=#net7}
N 860 -1350 860 -1340 {
lab=#net7}
N 2330 -1540 2330 -1520 {
lab=RESET}
N 2330 -1520 2340 -1520 {
lab=RESET}
N 2310 -1540 2310 -1500 {
lab=Vcmp}
N 2310 -1500 2340 -1500 {
lab=Vcmp}
N 2290 -1540 2290 -1500 {
lab=#net21}
N 2270 -1380 2270 -1360 {
lab=clk_8.9}
N 2310 -1750 2310 -1720 {
lab=SW8.9p}
N 2310 -1750 2320 -1750 {
lab=SW8.9p}
N 2290 -1770 2290 -1720 {
lab=SW8.9n}
N 2290 -1770 2320 -1770 {
lab=SW8.9n}
N 2270 -1770 2290 -1770 {
lab=SW8.9n}
N 2260 -1770 2270 -1770 {
lab=bit8.9}
N 2540 -1540 2540 -1520 {
lab=RESET}
N 2540 -1520 2550 -1520 {
lab=RESET}
N 2520 -1540 2520 -1500 {
lab=Vcmp}
N 2520 -1500 2550 -1500 {
lab=Vcmp}
N 2500 -1540 2500 -1500 {
lab=#net22}
N 2480 -1380 2480 -1360 {
lab=clk_8.10}
N 2520 -1750 2520 -1720 {
lab=SW8.10p}
N 2520 -1750 2530 -1750 {
lab=SW8.10p}
N 2500 -1770 2500 -1720 {
lab=SW8.10n}
N 2500 -1770 2530 -1770 {
lab=SW8.10n}
N 2480 -1770 2500 -1770 {
lab=SW8.10n}
N 2470 -1770 2480 -1770 {
lab=bit8.10}
N 2950 -1540 2950 -1520 {
lab=RESET}
N 2950 -1520 2960 -1520 {
lab=RESET}
N 2930 -1540 2930 -1500 {
lab=Vcmp}
N 2930 -1500 2960 -1500 {
lab=Vcmp}
N 2910 -1540 2910 -1500 {
lab=#net23}
N 2930 -1750 2930 -1720 {
lab=SW9p}
N 2930 -1750 2940 -1750 {
lab=SW9p}
N 2910 -1770 2910 -1720 {
lab=SW9n}
N 2910 -1770 2940 -1770 {
lab=SW9n}
N 2890 -1770 2910 -1770 {
lab=SW9n}
N 2880 -1770 2890 -1770 {
lab=bit9}
N 2910 -1500 2910 -1330 {
lab=#net23}
N 2890 -1340 2890 -1330 {
lab=#net24}
N 2310 -1380 2310 -1340 {
lab=#net24}
N 2890 -1120 2890 -1100 {
lab=clk_9}
N 2910 -1120 2910 -1100 {
lab=#net25}
N 2860 -1100 2890 -1100 {
lab=clk_9}
N 2890 -980 2890 -960 {
lab=bit5}
N 2930 -980 2930 -960 {
lab=Vcmp}
N 3140 -1540 3140 -1520 {
lab=RESET}
N 3140 -1520 3150 -1520 {
lab=RESET}
N 3120 -1540 3120 -1500 {
lab=Vcmp}
N 3120 -1500 3150 -1500 {
lab=Vcmp}
N 3100 -1540 3100 -1500 {
lab=#net26}
N 3120 -1750 3120 -1720 {
lab=SW10p}
N 3120 -1750 3130 -1750 {
lab=SW10p}
N 3100 -1770 3100 -1720 {
lab=SW10n}
N 3100 -1770 3130 -1770 {
lab=SW10n}
N 3080 -1770 3100 -1770 {
lab=SW10n}
N 3070 -1770 3080 -1770 {
lab=bit10}
N 3100 -1500 3100 -1330 {
lab=#net26}
N 3080 -1340 3080 -1330 {
lab=#net27}
N 3080 -1120 3080 -1100 {
lab=clk_10}
N 3100 -1120 3100 -1100 {
lab=#net28}
N 3050 -1100 3080 -1100 {
lab=clk_10}
N 3080 -980 3080 -960 {
lab=bit7}
N 3120 -980 3120 -960 {
lab=Vcmp}
N 2520 -1380 2520 -1360 {
lab=#net27}
N 2750 -1540 2750 -1520 {
lab=RESET}
N 2750 -1520 2760 -1520 {
lab=RESET}
N 2730 -1540 2730 -1500 {
lab=Vcmp}
N 2730 -1500 2760 -1500 {
lab=Vcmp}
N 2710 -1540 2710 -1500 {
lab=#net29}
N 2690 -1380 2690 -1360 {
lab=clk_8.11}
N 2730 -1750 2730 -1720 {
lab=SW8.11p}
N 2730 -1750 2740 -1750 {
lab=SW8.11p}
N 2710 -1770 2710 -1720 {
lab=SW8.11n}
N 2710 -1770 2740 -1770 {
lab=SW8.11n}
N 2690 -1770 2710 -1770 {
lab=SW8.11n}
N 2680 -1770 2690 -1770 {
lab=bit8.11}
N 2730 -1380 2730 -1360 {
lab=#net30}
N 3330 -1540 3330 -1520 {
lab=RESET}
N 3330 -1520 3340 -1520 {
lab=RESET}
N 3310 -1540 3310 -1500 {
lab=Vcmp}
N 3310 -1500 3340 -1500 {
lab=Vcmp}
N 3290 -1540 3290 -1500 {
lab=#net31}
N 3310 -1750 3310 -1720 {
lab=SW11p}
N 3310 -1750 3320 -1750 {
lab=SW11p}
N 3290 -1770 3290 -1720 {
lab=SW11n}
N 3290 -1770 3320 -1770 {
lab=SW11n}
N 3270 -1770 3290 -1770 {
lab=SW11n}
N 3260 -1770 3270 -1770 {
lab=bit11}
N 3290 -1500 3290 -1330 {
lab=#net31}
N 3270 -1340 3270 -1330 {
lab=#net30}
N 3270 -1120 3270 -1100 {
lab=clk_11}
N 3290 -1120 3290 -1100 {
lab=#net32}
N 3240 -1100 3270 -1100 {
lab=clk_11}
N 3270 -980 3270 -960 {
lab=bit8}
N 3310 -980 3310 -960 {
lab=Vcmp}
N 3270 -1360 3270 -1340 {
lab=#net30}
N 2310 -1340 2890 -1340 {
lab=#net24}
N 2520 -1360 2520 -1350 {
lab=#net27}
N 2520 -1350 3080 -1350 {
lab=#net27}
N 3080 -1350 3080 -1340 {
lab=#net27}
N 2730 -1360 3270 -1360 {
lab=#net30}
N 3540 -1540 3540 -1520 {
lab=RESET}
N 3540 -1520 3550 -1520 {
lab=RESET}
N 3520 -1540 3520 -1500 {
lab=Vcmp}
N 3520 -1500 3550 -1500 {
lab=Vcmp}
N 3500 -1540 3500 -1500 {
lab=clk_12}
N 3520 -1750 3520 -1720 {
lab=SW12p}
N 3520 -1750 3530 -1750 {
lab=SW12p}
N 3500 -1770 3500 -1720 {
lab=SW12n}
N 3500 -1770 3530 -1770 {
lab=SW12n}
N 3480 -1770 3500 -1770 {
lab=SW12n}
N 3470 -1770 3480 -1770 {
lab=bit12}
N 3750 -1540 3750 -1520 {
lab=RESET}
N 3750 -1520 3760 -1520 {
lab=RESET}
N 3730 -1540 3730 -1500 {
lab=Vcmp}
N 3730 -1500 3760 -1500 {
lab=Vcmp}
N 3710 -1540 3710 -1500 {
lab=clk_13}
N 3710 -1770 3710 -1720 {
lab=bit13}
N 3690 -1770 3710 -1770 {
lab=bit13}
N 3680 -1770 3690 -1770 {
lab=bit13}
N 610 -2210 660 -2210 {
lab=#net33}
N 660 -2220 660 -2210 {
lab=#net33}
N 500 -2180 510 -2180 {
lab=clk_dump_bus}
N 500 -2180 500 -2140 {
lab=clk_dump_bus}
N 500 -2140 510 -2140 {
lab=clk_dump_bus}
N 490 -2120 510 -2120 {
lab=#net34}
N 750 -2180 760 -2180 {
lab=clk_dump_bus}
N 750 -2180 750 -2140 {
lab=clk_dump_bus}
N 750 -2140 760 -2140 {
lab=clk_dump_bus}
N 740 -2220 740 -2120 {
lab=#net35}
N 740 -2120 760 -2120 {
lab=#net35}
N 490 -2350 490 -2340 {
lab=#net33}
N 490 -2220 490 -2120 {
lab=#net34}
N 590 -2210 610 -2210 {
lab=#net33}
N 400 -2360 410 -2360 {
lab=bit1.2}
N 410 -2360 410 -2340 {
lab=bit1.2}
N 400 -2380 450 -2380 {
lab=bit2}
N 450 -2380 450 -2340 {
lab=bit2}
N 550 -2210 590 -2210 {}
N 550 -2350 550 -2210 {}
N 490 -2350 550 -2350 {}
N 650 -2360 660 -2360 {}
N 660 -2360 660 -2340 {}
N 650 -2380 700 -2380 {}
N 700 -2380 700 -2340 {}
N 860 -2210 910 -2210 {
lab=#net33}
N 910 -2220 910 -2210 {
lab=#net33}
N 740 -2350 740 -2340 {
lab=#net33}
N 840 -2210 860 -2210 {
lab=#net33}
N 800 -2210 840 -2210 {}
N 800 -2350 800 -2210 {}
N 740 -2350 800 -2350 {}
N 1110 -2210 1160 -2210 {
lab=#net33}
N 1160 -2220 1160 -2210 {
lab=#net33}
N 1000 -2180 1010 -2180 {
lab=clk_dump_bus}
N 1000 -2180 1000 -2140 {
lab=clk_dump_bus}
N 1000 -2140 1010 -2140 {
lab=clk_dump_bus}
N 990 -2120 1010 -2120 {
lab=#net34}
N 1250 -2180 1260 -2180 {
lab=clk_dump_bus}
N 1250 -2180 1250 -2140 {
lab=clk_dump_bus}
N 1250 -2140 1260 -2140 {
lab=clk_dump_bus}
N 1240 -2220 1240 -2120 {
lab=#net35}
N 1240 -2120 1260 -2120 {
lab=#net35}
N 990 -2350 990 -2340 {
lab=#net33}
N 990 -2220 990 -2120 {
lab=#net34}
N 1090 -2210 1110 -2210 {
lab=#net33}
N 900 -2360 910 -2360 {
lab=bit1.2}
N 910 -2360 910 -2340 {
lab=bit1.2}
N 900 -2380 950 -2380 {
lab=bit2}
N 950 -2380 950 -2340 {
lab=bit2}
N 1050 -2210 1090 -2210 {}
N 1050 -2350 1050 -2210 {}
N 990 -2350 1050 -2350 {}
N 1150 -2360 1160 -2360 {}
N 1160 -2360 1160 -2340 {}
N 1150 -2380 1200 -2380 {}
N 1200 -2380 1200 -2340 {}
N 1360 -2210 1410 -2210 {
lab=#net33}
N 1410 -2220 1410 -2210 {
lab=#net33}
N 1240 -2350 1240 -2340 {
lab=#net33}
N 1340 -2210 1360 -2210 {
lab=#net33}
N 1300 -2210 1340 -2210 {}
N 1300 -2350 1300 -2210 {}
N 1240 -2350 1300 -2350 {}
N 1610 -2210 1660 -2210 {
lab=#net33}
N 1660 -2220 1660 -2210 {
lab=#net33}
N 1500 -2180 1510 -2180 {
lab=clk_dump_bus}
N 1500 -2180 1500 -2140 {
lab=clk_dump_bus}
N 1500 -2140 1510 -2140 {
lab=clk_dump_bus}
N 1490 -2120 1510 -2120 {
lab=#net34}
N 1750 -2180 1760 -2180 {
lab=clk_dump_bus}
N 1750 -2180 1750 -2140 {
lab=clk_dump_bus}
N 1750 -2140 1760 -2140 {
lab=clk_dump_bus}
N 1740 -2220 1740 -2120 {
lab=#net35}
N 1740 -2120 1760 -2120 {
lab=#net35}
N 1490 -2350 1490 -2340 {
lab=#net33}
N 1490 -2220 1490 -2120 {
lab=#net34}
N 1590 -2210 1610 -2210 {
lab=#net33}
N 1400 -2360 1410 -2360 {
lab=bit1.2}
N 1410 -2360 1410 -2340 {
lab=bit1.2}
N 1400 -2380 1450 -2380 {
lab=bit2}
N 1450 -2380 1450 -2340 {
lab=bit2}
N 1550 -2210 1590 -2210 {}
N 1550 -2350 1550 -2210 {}
N 1490 -2350 1550 -2350 {}
N 1650 -2360 1660 -2360 {}
N 1660 -2360 1660 -2340 {}
N 1650 -2380 1700 -2380 {}
N 1700 -2380 1700 -2340 {}
N 1860 -2210 1910 -2210 {
lab=#net33}
N 1910 -2220 1910 -2210 {
lab=#net33}
N 1740 -2350 1740 -2340 {
lab=#net33}
N 1840 -2210 1860 -2210 {
lab=#net33}
N 1800 -2210 1840 -2210 {}
N 1800 -2350 1800 -2210 {}
N 1740 -2350 1800 -2350 {}
N 2110 -2210 2160 -2210 {
lab=#net33}
N 2160 -2220 2160 -2210 {
lab=#net33}
N 2000 -2180 2010 -2180 {
lab=clk_dump_bus}
N 2000 -2180 2000 -2140 {
lab=clk_dump_bus}
N 2000 -2140 2010 -2140 {
lab=clk_dump_bus}
N 1990 -2120 2010 -2120 {
lab=#net34}
N 2250 -2180 2260 -2180 {
lab=clk_dump_bus}
N 2250 -2180 2250 -2140 {
lab=clk_dump_bus}
N 2250 -2140 2260 -2140 {
lab=clk_dump_bus}
N 2240 -2220 2240 -2120 {
lab=#net35}
N 2240 -2120 2260 -2120 {
lab=#net35}
N 1990 -2350 1990 -2340 {
lab=#net33}
N 1990 -2220 1990 -2120 {
lab=#net34}
N 2090 -2210 2110 -2210 {
lab=#net33}
N 1900 -2360 1910 -2360 {
lab=bit1.2}
N 1910 -2360 1910 -2340 {
lab=bit1.2}
N 1900 -2380 1950 -2380 {
lab=bit2}
N 1950 -2380 1950 -2340 {
lab=bit2}
N 2050 -2210 2090 -2210 {}
N 2050 -2350 2050 -2210 {}
N 1990 -2350 2050 -2350 {}
N 2150 -2360 2160 -2360 {}
N 2160 -2360 2160 -2340 {}
N 2150 -2380 2200 -2380 {}
N 2200 -2380 2200 -2340 {}
N 2240 -2350 2240 -2340 {
lab=#net33}
N 250 -2180 260 -2180 {
lab=clk_dump_bus}
N 250 -2180 250 -2140 {
lab=clk_dump_bus}
N 250 -2140 260 -2140 {
lab=clk_dump_bus}
N 240 -2120 260 -2120 {
lab=#net34}
N 410 -2220 410 -2210 {}
N 240 -2210 410 -2210 {}
N 240 -2210 240 -2120 {}
N 2500 -2180 2510 -2180 {
lab=clk_dump_bus}
N 2500 -2180 2500 -2140 {
lab=clk_dump_bus}
N 2500 -2140 2510 -2140 {
lab=clk_dump_bus}
N 2490 -2120 2510 -2120 {
lab=#net34}
N 2240 -2360 2250 -2360 {}
N 2240 -2360 2240 -2350 {}
N 2490 -2220 2490 -2120 {}
N 2480 -2220 2490 -2220 {}
N 340 -620 340 -600 {
lab=clk_1.2}
N 340 -600 360 -600 {
lab=clk_1.2}
N 350 -660 360 -660 {
lab=clk}
N 360 -660 360 -620 {
lab=clk}
N 540 -620 540 -600 {
lab=clk_1.3}
N 540 -600 560 -600 {
lab=clk_1.3}
N 550 -660 560 -660 {
lab=clk}
N 560 -660 560 -620 {
lab=clk}
N 350 -600 350 -570 {
lab=clk_1.2}
N 550 -600 550 -570 {
lab=clk_1.3}
N 740 -620 740 -600 {
lab=clk_2}
N 740 -600 760 -600 {
lab=clk_2}
N 750 -660 760 -660 {
lab=clk}
N 760 -660 760 -620 {
lab=clk}
N 940 -620 940 -600 {
lab=clk_3}
N 940 -600 960 -600 {
lab=clk_3}
N 950 -660 960 -660 {
lab=clk}
N 960 -660 960 -620 {
lab=clk}
N 750 -600 750 -570 {
lab=clk_2}
N 950 -600 950 -570 {
lab=clk_3}
N 1140 -620 1140 -600 {
lab=clk_4.5}
N 1140 -600 1160 -600 {
lab=clk_4.5}
N 1150 -660 1160 -660 {
lab=clk}
N 1160 -660 1160 -620 {
lab=clk}
N 1340 -620 1340 -600 {
lab=clk_4.6}
N 1340 -600 1360 -600 {
lab=clk_4.6}
N 1350 -660 1360 -660 {
lab=clk}
N 1360 -660 1360 -620 {
lab=clk}
N 1150 -600 1150 -570 {
lab=clk_4.5}
N 1350 -600 1350 -570 {
lab=clk_4.6}
N 1540 -620 1540 -600 {
lab=clk_4.7}
N 1540 -600 1560 -600 {
lab=clk_4.7}
N 1550 -660 1560 -660 {
lab=clk}
N 1560 -660 1560 -620 {
lab=clk}
N 1740 -620 1740 -600 {
lab=clk_5}
N 1740 -600 1760 -600 {
lab=clk_5}
N 1750 -660 1760 -660 {
lab=clk}
N 1760 -660 1760 -620 {
lab=clk}
N 1550 -600 1550 -570 {
lab=clk_4.7}
N 1750 -600 1750 -570 {
lab=clk_5}
N 1940 -620 1940 -600 {
lab=clk_6}
N 1940 -600 1960 -600 {
lab=clk_6}
N 1950 -660 1960 -660 {
lab=clk}
N 1960 -660 1960 -620 {
lab=clk}
N 2140 -620 2140 -600 {
lab=clk_7}
N 2140 -600 2160 -600 {
lab=clk_7}
N 2150 -660 2160 -660 {
lab=clk}
N 2160 -660 2160 -620 {
lab=clk}
N 1950 -600 1950 -570 {
lab=clk_6}
N 2150 -600 2150 -570 {
lab=clk_7}
N 2340 -620 2340 -600 {
lab=clk_8.9}
N 2340 -600 2360 -600 {
lab=clk_8.9}
N 2350 -660 2360 -660 {
lab=clk}
N 2360 -660 2360 -620 {
lab=clk}
N 2350 -600 2350 -570 {
lab=clk_8.9}
N 150 -660 160 -660 {
lab=clk}
N 160 -660 160 -620 {
lab=clk}
N 150 -600 160 -600 {
lab=clk_pulse}
N 2540 -620 2580 -620 {}
N 2580 -710 2580 -620 {}
N 160 -710 2580 -710 {}
N 160 -790 160 -710 {}
N 160 -600 160 -560 {}
N 160 -560 160 -550 {}
N 160 -550 170 -550 {}
N 2580 -620 2580 -540 {}
N 2580 -540 2630 -540 {}
N 2350 -570 2350 -500 {}
N 2350 -500 2630 -500 {}
N 2150 -460 2630 -460 {}
N 2150 -570 2150 -460 {}
N 1950 -420 2630 -420 {}
N 1950 -570 1950 -420 {}
N 1750 -570 1750 -450 {}
N 1750 -450 1810 -450 {}
N 1550 -410 1810 -410 {}
N 1550 -570 1550 -410 {}
N 1350 -370 1810 -370 {}
N 1350 -570 1350 -370 {}
N 1150 -570 1150 -330 {}
N 1150 -330 1810 -330 {}
N 950 -570 950 -360 {}
N 950 -360 1020 -360 {}
N 750 -320 1020 -320 {}
N 750 -570 750 -320 {}
N 550 -570 550 -280 {}
N 550 -280 1020 -280 {}
N 350 -240 1020 -240 {}
N 350 -570 350 -240 {}
N 2750 -480 2840 -480 {}
N 2770 -440 2840 -440 {}
N 2770 -440 2770 -390 {}
N 1930 -390 2770 -390 {}
N 2780 -400 2840 -400 {}
N 2780 -400 2780 -310 {}
N 1140 -300 2780 -300 {}
N 2780 -310 2780 -300 {}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Dr. Aubrey Beal, Dr. Phillip Bailey, Micah Tseng"}
C {sky130_stdcells/dfxtp_2.sym} 460 -800 0 0 {name=x2 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfxtp_2.sym} 260 -800 0 0 {name=x1 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 360 -850 0 0 {name=l2 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 660 -800 0 0 {name=x3 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 560 -850 0 0 {name=l3 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 360 -760 0 0 {name=l4 sig_type=std_logic lab=clk_1.2
}
C {devices/lab_pin.sym} 560 -760 0 0 {name=l5 sig_type=std_logic lab=clk_1.3
}
C {sky130_stdcells/dfxtp_2.sym} 860 -800 0 0 {name=x4 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 760 -850 0 0 {name=l6 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1060 -800 0 0 {name=x5 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 960 -850 0 0 {name=l7 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 760 -760 0 0 {name=l8 sig_type=std_logic lab=clk_2

}
C {devices/lab_pin.sym} 960 -760 0 0 {name=l9 sig_type=std_logic lab=clk_3
}
C {sky130_stdcells/dfxtp_2.sym} 1260 -800 0 0 {name=x6 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1160 -850 0 0 {name=l10 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1460 -800 0 0 {name=x7 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1360 -850 0 0 {name=l11 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1160 -760 0 0 {name=l12 sig_type=std_logic lab=clk_4.5
}
C {devices/lab_pin.sym} 1360 -760 0 0 {name=l13 sig_type=std_logic lab=clk_4.6
}
C {sky130_stdcells/dfxtp_2.sym} 1660 -800 0 0 {name=x8 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1560 -850 0 0 {name=l14 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1860 -800 0 0 {name=x9 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1760 -850 0 0 {name=l15 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1560 -760 0 0 {name=l16 sig_type=std_logic lab=clk_4.7
}
C {devices/lab_pin.sym} 1760 -760 0 0 {name=l17 sig_type=std_logic lab=clk_5
}
C {sky130_stdcells/dfxtp_2.sym} 2060 -800 0 0 {name=x10 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1960 -850 0 0 {name=l18 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 2260 -800 0 0 {name=x11 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2160 -850 0 0 {name=l19 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1960 -760 0 0 {name=l20 sig_type=std_logic lab=clk_6
}
C {devices/lab_pin.sym} 2160 -760 0 0 {name=l21 sig_type=std_logic lab=clk_7
}
C {sky130_stdcells/dfxtp_2.sym} 2460 -800 0 0 {name=x12 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2360 -850 0 0 {name=l22 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 2660 -800 0 0 {name=x13 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2560 -850 0 0 {name=l23 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2360 -760 0 0 {name=l24 sig_type=std_logic lab=clk_8.9
}
C {devices/lab_pin.sym} 2560 -760 0 0 {name=l25 sig_type=std_logic lab=clk_8.10
}
C {sky130_stdcells/dfxtp_2.sym} 2860 -800 0 0 {name=x14 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2760 -850 0 0 {name=l26 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 3060 -800 0 0 {name=x15 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2960 -850 0 0 {name=l27 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2760 -760 0 0 {name=l28 sig_type=std_logic lab=clk_8.11
}
C {devices/lab_pin.sym} 2960 -760 0 0 {name=l29 sig_type=std_logic lab=clk_9
}
C {sky130_stdcells/dfxtp_2.sym} 3260 -800 0 0 {name=x16 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3160 -850 0 0 {name=l30 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 3460 -800 0 0 {name=x17 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3360 -850 0 0 {name=l31 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3160 -760 0 0 {name=l32 sig_type=std_logic lab=clk_10
}
C {devices/lab_pin.sym} 3360 -760 0 0 {name=l33 sig_type=std_logic lab=clk_11
}
C {sky130_stdcells/dfxtp_2.sym} 3660 -800 0 0 {name=x18 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3560 -850 0 0 {name=l34 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 3860 -800 0 0 {name=x19 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3760 -850 0 0 {name=l35 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3560 -760 0 0 {name=l36 sig_type=std_logic lab=clk_12
}
C {devices/lab_pin.sym} 3760 -760 0 0 {name=l37 sig_type=std_logic lab=clk_13
}
C {devices/lab_pin.sym} 160 -850 0 0 {name=l38 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 150 -600 0 0 {name=l39 sig_type=std_logic lab=clk_pulse}
C {sky130_stdcells/dfxtp_2.sym} 4060 -800 0 0 {name=x20 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3960 -850 0 0 {name=l40 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3960 -760 0 0 {name=l41 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 250 -550 2 0 {name=l42 sig_type=std_logic lab=RESET}
C {sky130_stdcells/dfrbp_1.sym} 290 -1630 3 0 {name=x21 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfsbp_1.sym} 710 -1630 3 0 {name=x22 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 270 -1440 3 0 {name=x23 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 320 -1500 2 0 {name=l43 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 320 -1520 2 0 {name=l44 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 250 -1360 0 0 {name=l45 sig_type=std_logic lab=clk_1.2
}
C {demux2.sym} 680 -1220 1 1 {name=x24}
C {devices/lab_pin.sym} 300 -1750 2 0 {name=l46 sig_type=std_logic lab=SW1.2p
}
C {devices/lab_pin.sym} 300 -1770 2 0 {name=l47 sig_type=std_logic lab=SW1.2n}
C {devices/lab_pin.sym} 240 -1770 0 0 {name=l48 sig_type=std_logic lab=bit1.2}
C {sky130_stdcells/dfrbp_1.sym} 500 -1630 3 0 {name=x25 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 480 -1440 3 0 {name=x26 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 530 -1500 2 0 {name=l49 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 530 -1520 2 0 {name=l50 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 460 -1360 0 0 {name=l51 sig_type=std_logic lab=clk_1.3
}
C {devices/lab_pin.sym} 510 -1750 2 0 {name=l52 sig_type=std_logic lab=SW1.3p
}
C {devices/lab_pin.sym} 510 -1770 2 0 {name=l53 sig_type=std_logic lab=SW1.3n}
C {devices/lab_pin.sym} 450 -1770 0 0 {name=l54 sig_type=std_logic lab=bit1.3}
C {devices/lab_pin.sym} 740 -1500 2 0 {name=l55 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 740 -1520 2 0 {name=l56 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 640 -1100 0 0 {name=l57 sig_type=std_logic lab=clk_2
}
C {devices/lab_pin.sym} 720 -1750 2 0 {name=l58 sig_type=std_logic lab=SW2p
}
C {devices/lab_pin.sym} 720 -1770 2 0 {name=l59 sig_type=std_logic lab=SW2n}
C {devices/lab_pin.sym} 660 -1770 0 0 {name=l60 sig_type=std_logic lab=bit2
}
C {sky130_stdcells/xor2_1.sym} 690 -1040 3 0 {name=x29 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 670 -960 0 0 {name=l61 sig_type=std_logic lab=bit2
}
C {devices/lab_pin.sym} 710 -960 2 0 {name=l62 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfsbp_1.sym} 900 -1630 3 0 {name=x28 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 870 -1220 1 1 {name=x30}
C {devices/lab_pin.sym} 930 -1500 2 0 {name=l63 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 930 -1520 2 0 {name=l64 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 830 -1100 0 0 {name=l65 sig_type=std_logic lab=clk_3
}
C {devices/lab_pin.sym} 910 -1750 2 0 {name=l66 sig_type=std_logic lab=SW3p
}
C {devices/lab_pin.sym} 910 -1770 2 0 {name=l67 sig_type=std_logic lab=SW3n
}
C {devices/lab_pin.sym} 850 -1770 0 0 {name=l68 sig_type=std_logic lab=bit3
}
C {sky130_stdcells/xor2_1.sym} 880 -1040 3 0 {name=x31 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 860 -960 0 0 {name=l69 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 900 -960 2 0 {name=l70 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 1100 -1630 3 0 {name=x27 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfsbp_1.sym} 1720 -1630 3 0 {name=x32 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 1080 -1440 3 0 {name=x33 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1130 -1500 2 0 {name=l71 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1130 -1520 2 0 {name=l72 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1060 -1360 0 0 {name=l73 sig_type=std_logic lab=clk_4.5
}
C {demux2.sym} 1690 -1220 1 1 {name=x34}
C {devices/lab_pin.sym} 1110 -1750 2 0 {name=l74 sig_type=std_logic lab=SW4.5p
}
C {devices/lab_pin.sym} 1110 -1770 2 0 {name=l75 sig_type=std_logic lab=SW4.5n
}
C {devices/lab_pin.sym} 1050 -1770 0 0 {name=l76 sig_type=std_logic lab=bit4.5
}
C {sky130_stdcells/dfrbp_1.sym} 1310 -1630 3 0 {name=x35 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 1290 -1440 3 0 {name=x36 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1340 -1500 2 0 {name=l77 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1340 -1520 2 0 {name=l78 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1270 -1360 0 0 {name=l79 sig_type=std_logic lab=clk_4.6
}
C {devices/lab_pin.sym} 1320 -1750 2 0 {name=l80 sig_type=std_logic lab=SW4.6p
}
C {devices/lab_pin.sym} 1320 -1770 2 0 {name=l81 sig_type=std_logic lab=SW4.6n
}
C {devices/lab_pin.sym} 1260 -1770 0 0 {name=l82 sig_type=std_logic lab=bit4.6
}
C {devices/lab_pin.sym} 1750 -1500 2 0 {name=l83 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1750 -1520 2 0 {name=l84 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1650 -1100 0 0 {name=l85 sig_type=std_logic lab=clk_5
}
C {devices/lab_pin.sym} 1730 -1750 2 0 {name=l86 sig_type=std_logic lab=SW5p
}
C {devices/lab_pin.sym} 1730 -1770 2 0 {name=l87 sig_type=std_logic lab=SW5n
}
C {devices/lab_pin.sym} 1670 -1770 0 0 {name=l88 sig_type=std_logic lab=bit5
}
C {sky130_stdcells/xor2_1.sym} 1700 -1040 3 0 {name=x37 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1680 -960 0 0 {name=l89 sig_type=std_logic lab=bit5
}
C {devices/lab_pin.sym} 1720 -960 2 0 {name=l90 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfsbp_1.sym} 1910 -1630 3 0 {name=x38 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 1880 -1220 1 1 {name=x39}
C {devices/lab_pin.sym} 1940 -1500 2 0 {name=l91 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1940 -1520 2 0 {name=l92 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1840 -1100 0 0 {name=l93 sig_type=std_logic lab=clk_6
}
C {devices/lab_pin.sym} 1920 -1750 2 0 {name=l94 sig_type=std_logic lab=SW6p
}
C {devices/lab_pin.sym} 1920 -1770 2 0 {name=l95 sig_type=std_logic lab=SW6n
}
C {devices/lab_pin.sym} 1860 -1770 0 0 {name=l96 sig_type=std_logic lab=bit6
}
C {sky130_stdcells/xor2_1.sym} 1890 -1040 3 0 {name=x40 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1870 -960 0 0 {name=l97 sig_type=std_logic lab=bit7
}
C {devices/lab_pin.sym} 1910 -960 2 0 {name=l98 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 1520 -1630 3 0 {name=x41 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 1500 -1440 3 0 {name=x42 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1550 -1500 2 0 {name=l99 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 1550 -1520 2 0 {name=l100 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 1480 -1360 0 0 {name=l101 sig_type=std_logic lab=clk_4.7
}
C {devices/lab_pin.sym} 1530 -1750 2 0 {name=l102 sig_type=std_logic lab=SW4.7p
}
C {devices/lab_pin.sym} 1530 -1770 2 0 {name=l103 sig_type=std_logic lab=SW4.7n
}
C {devices/lab_pin.sym} 1470 -1770 0 0 {name=l104 sig_type=std_logic lab=bit4.7
}
C {sky130_stdcells/dfsbp_1.sym} 2100 -1630 3 0 {name=x43 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 2070 -1220 1 1 {name=x44}
C {devices/lab_pin.sym} 2130 -1500 2 0 {name=l105 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2130 -1520 2 0 {name=l106 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2030 -1100 0 0 {name=l107 sig_type=std_logic lab=clk_7
}
C {devices/lab_pin.sym} 2110 -1750 2 0 {name=l108 sig_type=std_logic lab=SW7p
}
C {devices/lab_pin.sym} 2110 -1770 2 0 {name=l109 sig_type=std_logic lab=SW7n
}
C {devices/lab_pin.sym} 2050 -1770 0 0 {name=l110 sig_type=std_logic lab=bit7
}
C {sky130_stdcells/xor2_1.sym} 2080 -1040 3 0 {name=x45 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2060 -960 0 0 {name=l111 sig_type=std_logic lab=bit8
}
C {devices/lab_pin.sym} 2100 -960 2 0 {name=l112 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 2310 -1630 3 0 {name=x46 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfsbp_1.sym} 2930 -1630 3 0 {name=x47 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 2290 -1440 3 0 {name=x48 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2340 -1500 2 0 {name=l113 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2340 -1520 2 0 {name=l114 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2270 -1360 0 0 {name=l115 sig_type=std_logic lab=clk_8.9
}
C {demux2.sym} 2900 -1220 1 1 {name=x49}
C {devices/lab_pin.sym} 2320 -1750 2 0 {name=l116 sig_type=std_logic lab=SW8.9p
}
C {devices/lab_pin.sym} 2320 -1770 2 0 {name=l117 sig_type=std_logic lab=SW8.9n
}
C {devices/lab_pin.sym} 2260 -1770 0 0 {name=l118 sig_type=std_logic lab=bit8.9
}
C {sky130_stdcells/dfrbp_1.sym} 2520 -1630 3 0 {name=x50 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 2500 -1440 3 0 {name=x51 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2550 -1500 2 0 {name=l119 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2550 -1520 2 0 {name=l120 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2480 -1360 0 0 {name=l121 sig_type=std_logic lab=clk_8.10
}
C {devices/lab_pin.sym} 2530 -1750 2 0 {name=l122 sig_type=std_logic lab=SW8.10p
}
C {devices/lab_pin.sym} 2530 -1770 2 0 {name=l123 sig_type=std_logic lab=SW8.10n
}
C {devices/lab_pin.sym} 2470 -1770 0 0 {name=l124 sig_type=std_logic lab=bit8.10
}
C {devices/lab_pin.sym} 2960 -1500 2 0 {name=l125 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2960 -1520 2 0 {name=l126 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2860 -1100 0 0 {name=l127 sig_type=std_logic lab=clk_9
}
C {devices/lab_pin.sym} 2940 -1750 2 0 {name=l128 sig_type=std_logic lab=SW9p
}
C {devices/lab_pin.sym} 2940 -1770 2 0 {name=l129 sig_type=std_logic lab=SW9n
}
C {devices/lab_pin.sym} 2880 -1770 0 0 {name=l130 sig_type=std_logic lab=bit9
}
C {sky130_stdcells/xor2_1.sym} 2910 -1040 3 0 {name=x52 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2890 -960 0 0 {name=l131 sig_type=std_logic lab=bit5
}
C {devices/lab_pin.sym} 2930 -960 2 0 {name=l132 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfsbp_1.sym} 3120 -1630 3 0 {name=x53 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 3090 -1220 1 1 {name=x54}
C {devices/lab_pin.sym} 3150 -1500 2 0 {name=l133 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 3150 -1520 2 0 {name=l134 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 3050 -1100 0 0 {name=l135 sig_type=std_logic lab=clk_10
}
C {devices/lab_pin.sym} 3130 -1750 2 0 {name=l136 sig_type=std_logic lab=SW10p
}
C {devices/lab_pin.sym} 3130 -1770 2 0 {name=l137 sig_type=std_logic lab=SW10n
}
C {devices/lab_pin.sym} 3070 -1770 0 0 {name=l138 sig_type=std_logic lab=bit10
}
C {sky130_stdcells/xor2_1.sym} 3100 -1040 3 0 {name=x55 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3080 -960 0 0 {name=l139 sig_type=std_logic lab=bit7
}
C {devices/lab_pin.sym} 3120 -960 2 0 {name=l140 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 2730 -1630 3 0 {name=x56 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or2_0.sym} 2710 -1440 3 0 {name=x57 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2760 -1500 2 0 {name=l141 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 2760 -1520 2 0 {name=l142 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 2690 -1360 0 0 {name=l143 sig_type=std_logic lab=clk_8.11
}
C {devices/lab_pin.sym} 2740 -1750 2 0 {name=l144 sig_type=std_logic lab=SW8.11p
}
C {devices/lab_pin.sym} 2740 -1770 2 0 {name=l145 sig_type=std_logic lab=SW8.11n
}
C {devices/lab_pin.sym} 2680 -1770 0 0 {name=l146 sig_type=std_logic lab=bit8.11
}
C {sky130_stdcells/dfsbp_1.sym} 3310 -1630 3 0 {name=x58 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {demux2.sym} 3280 -1220 1 1 {name=x59}
C {devices/lab_pin.sym} 3340 -1500 2 0 {name=l147 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 3340 -1520 2 0 {name=l148 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 3240 -1100 0 0 {name=l149 sig_type=std_logic lab=clk_11
}
C {devices/lab_pin.sym} 3320 -1750 2 0 {name=l150 sig_type=std_logic lab=SW11p
}
C {devices/lab_pin.sym} 3320 -1770 2 0 {name=l151 sig_type=std_logic lab=SW11n
}
C {devices/lab_pin.sym} 3260 -1770 0 0 {name=l152 sig_type=std_logic lab=bit11
}
C {sky130_stdcells/xor2_1.sym} 3290 -1040 3 0 {name=x60 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3270 -960 0 0 {name=l153 sig_type=std_logic lab=bit8
}
C {devices/lab_pin.sym} 3310 -960 2 0 {name=l154 sig_type=std_logic lab=Vcmp
}
C {sky130_stdcells/dfrbp_1.sym} 3520 -1630 3 0 {name=x61 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 3550 -1500 2 0 {name=l155 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 3550 -1520 2 0 {name=l156 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 3500 -1500 0 0 {name=l157 sig_type=std_logic lab=clk_12
}
C {devices/lab_pin.sym} 3530 -1750 2 0 {name=l158 sig_type=std_logic lab=SW12p
}
C {devices/lab_pin.sym} 3530 -1770 2 0 {name=l159 sig_type=std_logic lab=SW12n
}
C {devices/lab_pin.sym} 3470 -1770 0 0 {name=l160 sig_type=std_logic lab=bit12
}
C {devices/lab_pin.sym} 3760 -1500 2 0 {name=l161 sig_type=std_logic lab=Vcmp
}
C {devices/lab_pin.sym} 3760 -1520 2 0 {name=l162 sig_type=std_logic lab=RESET

}
C {devices/lab_pin.sym} 3710 -1500 0 0 {name=l163 sig_type=std_logic lab=clk_13
}
C {devices/lab_pin.sym} 3680 -1770 0 0 {name=l166 sig_type=std_logic lab=bit13
}
C {sky130_stdcells/dfrtp_1.sym} 3730 -1630 3 0 {name=x63 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 450 -2280 3 1 {name=x62 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 700 -2280 3 1 {name=x64 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 600 -2120 0 0 {name=x67 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 850 -2120 0 0 {name=x68 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 510 -2180 2 0 {name=l164 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 690 -2140 2 0 {name=l165 sig_type=std_logic lab=D2
}
C {devices/lab_pin.sym} 760 -2180 2 0 {name=l167 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 400 -2360 0 0 {name=l168 sig_type=std_logic lab=bit1.2
}
C {devices/lab_pin.sym} 400 -2380 0 0 {name=l169 sig_type=std_logic lab=bit2
}
C {devices/lab_pin.sym} 650 -2380 0 0 {name=l170 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 650 -2360 0 0 {name=l171 sig_type=std_logic lab=bit1.3
}
C {devices/lab_pin.sym} 940 -2140 2 0 {name=l172 sig_type=std_logic lab=D3
}
C {devices/lab_pin.sym} 510 -2100 0 0 {name=l173 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 760 -2100 0 0 {name=l174 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/fa_1.sym} 950 -2280 3 1 {name=x65 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 1200 -2280 3 1 {name=x69 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 1100 -2120 0 0 {name=x70 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 1350 -2120 0 0 {name=x71 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1010 -2180 2 0 {name=l175 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 1190 -2140 2 0 {name=l176 sig_type=std_logic lab=D4
}
C {devices/lab_pin.sym} 1260 -2180 2 0 {name=l177 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 900 -2360 0 0 {name=l178 sig_type=std_logic lab=bit4.5
}
C {devices/lab_pin.sym} 900 -2380 0 0 {name=l179 sig_type=std_logic lab=bit5
}
C {devices/lab_pin.sym} 1150 -2380 0 0 {name=l180 sig_type=std_logic lab=bit6
}
C {devices/lab_pin.sym} 1150 -2360 0 0 {name=l181 sig_type=std_logic lab=bit4.6
}
C {devices/lab_pin.sym} 1440 -2140 2 0 {name=l182 sig_type=std_logic lab=D5
}
C {devices/lab_pin.sym} 1010 -2100 0 0 {name=l183 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 1260 -2100 0 0 {name=l184 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/fa_1.sym} 1450 -2280 3 1 {name=x72 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 1700 -2280 3 1 {name=x73 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 1600 -2120 0 0 {name=x74 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 1850 -2120 0 0 {name=x75 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1510 -2180 2 0 {name=l185 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 1690 -2140 2 0 {name=l186 sig_type=std_logic lab=D6
}
C {devices/lab_pin.sym} 1760 -2180 2 0 {name=l187 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 1400 -2360 0 0 {name=l188 sig_type=std_logic lab=bit4.7
}
C {devices/lab_pin.sym} 1400 -2380 0 0 {name=l189 sig_type=std_logic lab=bit7
}
C {devices/lab_pin.sym} 1650 -2380 0 0 {name=l190 sig_type=std_logic lab=bit9
}
C {devices/lab_pin.sym} 1650 -2360 0 0 {name=l191 sig_type=std_logic lab=bit8.9
}
C {devices/lab_pin.sym} 1940 -2140 2 0 {name=l192 sig_type=std_logic lab=D7
}
C {devices/lab_pin.sym} 1510 -2100 0 0 {name=l193 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 1760 -2100 0 0 {name=l194 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/fa_1.sym} 1950 -2280 3 1 {name=x76 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/fa_1.sym} 2200 -2280 3 1 {name=x77 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 2100 -2120 0 0 {name=x78 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 2350 -2120 0 0 {name=x79 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2010 -2180 2 0 {name=l195 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 2190 -2140 2 0 {name=l196 sig_type=std_logic lab=D8
}
C {devices/lab_pin.sym} 2260 -2180 2 0 {name=l197 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 1900 -2360 0 0 {name=l198 sig_type=std_logic lab=bit8.10
}
C {devices/lab_pin.sym} 1900 -2380 0 0 {name=l199 sig_type=std_logic lab=bit10
}
C {devices/lab_pin.sym} 2150 -2380 0 0 {name=l200 sig_type=std_logic lab=bit11
}
C {devices/lab_pin.sym} 2150 -2360 0 0 {name=l201 sig_type=std_logic lab=bit8.11
}
C {devices/lab_pin.sym} 2440 -2140 2 0 {name=l202 sig_type=std_logic lab=D9
}
C {devices/lab_pin.sym} 2010 -2100 0 0 {name=l203 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 2260 -2100 0 0 {name=l204 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/dfrtp_1.sym} 350 -2120 0 0 {name=x80 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 260 -2180 2 0 {name=l205 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 440 -2140 2 0 {name=l206 sig_type=std_logic lab=D1
}
C {devices/lab_pin.sym} 260 -2100 0 0 {name=l207 sig_type=std_logic lab=RST_OUT
}
C {sky130_stdcells/dfrtp_1.sym} 2600 -2120 0 0 {name=x81 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2510 -2180 2 0 {name=l208 sig_type=std_logic lab=clk_dump_bus
}
C {devices/lab_pin.sym} 2690 -2140 2 0 {name=l209 sig_type=std_logic lab=D10
}
C {devices/lab_pin.sym} 2510 -2100 0 0 {name=l210 sig_type=std_logic lab=RST_OUT
}
C {devices/lab_pin.sym} 2250 -2360 2 0 {name=l211 sig_type=std_logic lab=bit12
}
C {devices/lab_pin.sym} 2480 -2220 0 0 {name=l212 sig_type=std_logic lab=bit13
}
C {devices/lab_pin.sym} 300 -2030 0 0 {name=l213 sig_type=std_logic lab=clk_dump_bus
}
C {sky130_stdcells/inv_1.sym} 340 -2030 0 0 {name=x82 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 380 -2030 2 0 {name=l214 sig_type=std_logic lab=done
}
C {devices/code.sym} 10 -140 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false}
C {devices/code.sym} 10 -300 0 0 {name=STIMULI 
only_toplevel=true
value="
.options acct list
.temp 25
vvcc VCC 0 dc 1.8
*vvss GND 0 0
.control
tran 0.1u 400u
* plot a b+2 clk+4 reset_b+6 x+8 y+10 q+12 qlatch+14
plot RST_PLS-2 clk clk2+2 clk4+4 clk8+6 clk16+8 clk32+10 clk64+12 delayed+14 pulse+16
write pulse_generator.raw
.endc
"}
C {sky130_stdcells/dfxtp_2.sym} 450 -610 0 0 {name=x83 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfxtp_2.sym} 250 -610 0 0 {name=x84 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 350 -660 0 0 {name=l215 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 650 -610 0 0 {name=x85 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 550 -660 0 0 {name=l216 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 850 -610 0 0 {name=x86 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 750 -660 0 0 {name=l219 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1050 -610 0 0 {name=x87 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 950 -660 0 0 {name=l220 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1250 -610 0 0 {name=x88 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1150 -660 0 0 {name=l223 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1450 -610 0 0 {name=x89 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1350 -660 0 0 {name=l224 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1650 -610 0 0 {name=x90 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1550 -660 0 0 {name=l227 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 1850 -610 0 0 {name=x91 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1750 -660 0 0 {name=l228 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 2050 -610 0 0 {name=x92 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1950 -660 0 0 {name=l231 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 2250 -610 0 0 {name=x93 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2150 -660 0 0 {name=l232 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfxtp_2.sym} 2450 -610 0 0 {name=x94 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2350 -660 0 0 {name=l235 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 150 -660 0 0 {name=l251 sig_type=std_logic lab=clk

}
C {sky130_stdcells/inv_1.sym} 210 -550 0 0 {name=x66 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or4_2.sym} 2690 -480 0 0 {name=x95 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or4_2.sym} 1870 -390 0 0 {name=x96 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or4_2.sym} 1080 -300 0 0 {name=x97 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/or3_1.sym} 2900 -440 0 0 {name=x98 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
