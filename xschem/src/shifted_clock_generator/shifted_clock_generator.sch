v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {need to add clk buffers here?} 640 -1200 0 0 0.4 0.4 {}
N 2790 -480 2800 -480 {
lab=clk}
N 2800 -480 2800 -440 {
lab=clk}
N 2990 -480 3000 -480 {
lab=clk}
N 3000 -480 3000 -440 {
lab=clk}
N 3190 -480 3200 -480 {
lab=clk}
N 3200 -480 3200 -440 {
lab=clk}
N 3390 -480 3400 -480 {
lab=clk}
N 3400 -480 3400 -440 {
lab=clk}
N 3590 -480 3600 -480 {
lab=clk}
N 3600 -480 3600 -440 {
lab=clk}
N 3790 -480 3800 -480 {
lab=clk}
N 3800 -480 3800 -440 {
lab=clk}
N 3990 -480 4000 -480 {
lab=clk}
N 4000 -480 4000 -440 {
lab=clk}
N 4190 -480 4200 -480 {
lab=clk}
N 4200 -480 4200 -440 {
lab=clk}
N 4390 -480 4400 -480 {
lab=clk}
N 4400 -480 4400 -440 {
lab=clk}
N 4590 -480 4600 -480 {
lab=clk}
N 4600 -480 4600 -440 {
lab=clk}
N 4790 -480 4800 -480 {
lab=clk}
N 4800 -480 4800 -440 {
lab=clk}
N 4990 -480 5000 -480 {
lab=clk}
N 5000 -480 5000 -440 {
lab=clk}
N 5190 -480 5200 -480 {
lab=clk}
N 5200 -480 5200 -440 {
lab=clk}
N 5390 -480 5400 -480 {
lab=clk}
N 5400 -480 5400 -440 {
lab=clk}
N 5590 -480 5600 -480 {
lab=clk}
N 5600 -480 5600 -440 {
lab=clk}
N 5790 -480 5800 -480 {
lab=clk}
N 5800 -480 5800 -440 {
lab=clk}
N 5990 -480 6000 -480 {
lab=clk}
N 6000 -480 6000 -440 {
lab=clk}
N 2590 -480 2600 -480 {
lab=clk}
N 2600 -480 2600 -440 {
lab=clk}
N 6190 -480 6200 -480 {
lab=clk}
N 6200 -480 6200 -440 {
lab=clk}
N 6380 -440 6400 -440 {
lab=cycle31}
N 360 -440 360 -420 {
lab=cycle1}
N 360 -420 380 -420 {
lab=cycle1}
N 380 -480 380 -440 {
lab=clk}
N 580 -480 580 -440 {
lab=clk}
N 780 -480 780 -440 {
lab=clk}
N 980 -480 980 -440 {
lab=clk}
N 1170 -480 1180 -480 {
lab=clk}
N 1180 -480 1180 -440 {
lab=clk}
N 1370 -480 1380 -480 {
lab=clk}
N 1380 -480 1380 -440 {
lab=clk}
N 1570 -480 1580 -480 {
lab=clk}
N 1580 -480 1580 -440 {
lab=clk}
N 1770 -480 1780 -480 {
lab=clk}
N 1780 -480 1780 -440 {
lab=clk}
N 1970 -480 1980 -480 {
lab=clk}
N 1980 -480 1980 -440 {
lab=clk}
N 2170 -480 2180 -480 {
lab=clk}
N 2180 -480 2180 -440 {
lab=clk}
N 2370 -480 2380 -480 {
lab=clk}
N 2380 -480 2380 -440 {
lab=clk}
N 170 -480 180 -480 {
lab=clk}
N 180 -480 180 -440 {
lab=clk}
N 170 -420 180 -420 {
lab=clk_pulse}
N 6400 -440 6400 -390 {
lab=cycle31}
N 160 -310 170 -310 {
lab=clk_pulse}
N 250 -310 280 -310 {
lab=cycle0}
N 160 -340 160 -310 {
lab=clk_pulse}
N 360 -420 360 -370 {
lab=cycle1}
N 380 -400 380 -370 {
lab=reset_b}
N 380 -400 380 -370 {
lab=reset_b}
N 580 -400 580 -370 {
lab=reset_b}
N 580 -400 580 -370 {
lab=reset_b}
N 780 -400 780 -370 {
lab=reset_b}
N 780 -400 780 -370 {
lab=reset_b}
N 980 -400 980 -370 {
lab=reset_b}
N 980 -400 980 -370 {
lab=reset_b}
N 1180 -400 1180 -370 {
lab=reset_b}
N 1180 -400 1180 -370 {
lab=reset_b}
N 1380 -400 1380 -370 {
lab=reset_b}
N 1380 -400 1380 -370 {
lab=reset_b}
N 1580 -400 1580 -370 {
lab=reset_b}
N 1580 -400 1580 -370 {
lab=reset_b}
N 1780 -400 1780 -370 {
lab=reset_b}
N 1780 -400 1780 -370 {
lab=reset_b}
N 1980 -400 1980 -370 {
lab=reset_b}
N 1980 -400 1980 -370 {
lab=reset_b}
N 2180 -400 2180 -370 {
lab=reset_b}
N 2180 -400 2180 -370 {
lab=reset_b}
N 2380 -400 2380 -370 {
lab=reset_b}
N 2380 -400 2380 -370 {
lab=reset_b}
N 2600 -400 2600 -370 {
lab=reset_b}
N 2600 -400 2600 -370 {
lab=reset_b}
N 3000 -400 3000 -370 {
lab=reset_b}
N 3000 -400 3000 -370 {
lab=reset_b}
N 3200 -400 3200 -370 {
lab=reset_b}
N 3200 -400 3200 -370 {
lab=reset_b}
N 3400 -400 3400 -370 {
lab=reset_b}
N 3400 -400 3400 -370 {
lab=reset_b}
N 3600 -400 3600 -370 {
lab=reset_b}
N 3600 -400 3600 -370 {
lab=reset_b}
N 3800 -400 3800 -370 {
lab=reset_b}
N 3800 -400 3800 -370 {
lab=reset_b}
N 4000 -400 4000 -370 {
lab=reset_b}
N 4000 -400 4000 -370 {
lab=reset_b}
N 4200 -400 4200 -370 {
lab=reset_b}
N 4200 -400 4200 -370 {
lab=reset_b}
N 4400 -400 4400 -370 {
lab=reset_b}
N 4400 -400 4400 -370 {
lab=reset_b}
N 4600 -400 4600 -370 {
lab=reset_b}
N 4600 -400 4600 -370 {
lab=reset_b}
N 4800 -400 4800 -370 {
lab=reset_b}
N 4800 -400 4800 -370 {
lab=reset_b}
N 5000 -400 5000 -370 {
lab=reset_b}
N 5000 -400 5000 -370 {
lab=reset_b}
N 5200 -400 5200 -370 {
lab=reset_b}
N 5200 -400 5200 -370 {
lab=reset_b}
N 5400 -400 5400 -370 {
lab=reset_b}
N 5400 -400 5400 -370 {
lab=reset_b}
N 5600 -400 5600 -370 {
lab=reset_b}
N 5600 -400 5600 -370 {
lab=reset_b}
N 5800 -400 5800 -370 {
lab=reset_b}
N 5800 -400 5800 -370 {
lab=reset_b}
N 6000 -400 6000 -370 {
lab=reset_b}
N 6000 -400 6000 -370 {
lab=reset_b}
N 6200 -400 6200 -370 {
lab=reset_b}
N 6200 -400 6200 -370 {
lab=reset_b}
N 560 -440 560 -370 {
lab=cycle2}
N 560 -420 580 -420 {
lab=cycle2}
N 760 -440 760 -370 {
lab=cycle3}
N 760 -420 780 -420 {
lab=cycle3}
N 960 -440 960 -370 {
lab=cycle4}
N 960 -420 980 -420 {
lab=cycle4}
N 1160 -440 1160 -370 {
lab=cycle5}
N 1160 -420 1180 -420 {
lab=cycle5}
N 1360 -440 1360 -370 {
lab=cycle6}
N 1360 -420 1380 -420 {
lab=cycle6}
N 1560 -440 1560 -370 {
lab=cycle7}
N 1560 -420 1580 -420 {
lab=cycle7}
N 1760 -440 1760 -370 {
lab=cycle8}
N 1760 -420 1780 -420 {
lab=cycle8}
N 1960 -440 1960 -370 {
lab=cycle9}
N 1960 -420 1980 -420 {
lab=cycle9}
N 2160 -440 2160 -370 {
lab=cycle10}
N 2160 -420 2180 -420 {
lab=cycle10}
N 2360 -440 2360 -370 {
lab=cycle11}
N 2360 -420 2380 -420 {
lab=cycle11}
N 2560 -440 2560 -370 {
lab=cycle12}
N 2560 -420 2600 -420 {
lab=cycle12}
N 2780 -440 2780 -370 {
lab=cycle13}
N 2780 -420 2800 -420 {
lab=cycle13}
N 2980 -440 2980 -370 {
lab=cycle14}
N 2980 -420 3000 -420 {
lab=cycle14}
N 3180 -440 3180 -370 {
lab=cycle15}
N 3180 -420 3200 -420 {
lab=cycle15}
N 3380 -420 3400 -420 {
lab=cycle16}
N 3380 -440 3380 -370 {
lab=cycle16}
N 3580 -440 3580 -370 {
lab=cycle17}
N 3580 -420 3600 -420 {
lab=cycle17}
N 3780 -440 3780 -370 {
lab=cycle18}
N 3780 -420 3800 -420 {
lab=cycle18}
N 3980 -440 3980 -370 {
lab=cycle19}
N 3980 -420 4000 -420 {
lab=cycle19}
N 4180 -440 4180 -370 {
lab=cycle20}
N 4180 -420 4200 -420 {
lab=cycle20}
N 4380 -440 4380 -370 {
lab=cycle21}
N 4380 -420 4400 -420 {
lab=cycle21}
N 4580 -440 4580 -370 {
lab=cycle22}
N 4580 -420 4600 -420 {
lab=cycle22}
N 4780 -440 4780 -370 {
lab=cycle23}
N 4780 -420 4800 -420 {
lab=cycle23}
N 4980 -440 4980 -370 {
lab=cycle24}
N 4980 -420 5000 -420 {
lab=cycle24}
N 5180 -440 5180 -370 {
lab=cycle25}
N 5180 -420 5200 -420 {
lab=cycle25}
N 5380 -440 5380 -370 {
lab=cycle26}
N 5380 -420 5400 -420 {
lab=cycle26}
N 5580 -440 5580 -370 {
lab=cycle27}
N 5580 -420 5600 -420 {
lab=cycle27}
N 5780 -440 5780 -370 {
lab=cycle28}
N 5780 -420 5800 -420 {
lab=cycle28}
N 5980 -440 5980 -370 {
lab=cycle29}
N 5980 -420 6000 -420 {
lab=cycle29}
N 6180 -440 6180 -370 {
lab=cycle30}
N 6400 -390 6400 -370 {
lab=cycle31}
N 130 -420 170 -420 {
lab=clk_pulse}
N 160 -420 160 -360 {
lab=clk_pulse}
N 180 -400 180 -360 {
lab=reset_b}
N 160 -360 160 -340 {
lab=clk_pulse}
N 2800 -400 2800 -370 {
lab=reset_b}
N 6180 -420 6200 -420 {
lab=cycle30}
N 70 -840 70 -790 {
lab=#net1}
N 70 -890 70 -840 {
lab=#net1}
N 90 -1050 90 -1010 {
lab=small_cycle1}
N 370 -480 380 -480 {
lab=clk}
N 770 -480 780 -480 {
lab=clk}
N 970 -480 980 -480 {
lab=clk}
N 570 -480 580 -480 {
lab=clk}
N 250 -850 250 -800 {
lab=#net1}
N 250 -900 250 -850 {
lab=#net1}
N 270 -1060 270 -1020 {
lab=small_cycle1}
N 430 -850 430 -800 {
lab=#net1}
N 430 -900 430 -850 {
lab=#net1}
N 450 -1060 450 -1020 {
lab=small_cycle1}
N 650 -860 650 -810 {
lab=#net1}
N 650 -910 650 -860 {
lab=#net1}
N 670 -1070 670 -1030 {
lab=small_cycle1}
N 830 -860 830 -810 {
lab=#net1}
N 830 -910 830 -860 {
lab=#net1}
N 850 -1070 850 -1030 {
lab=small_cycle1}
N 1040 -860 1040 -810 {
lab=#net1}
N 1040 -910 1040 -860 {
lab=#net1}
N 1060 -1070 1060 -1030 {
lab=small_cycle1}
N 1220 -860 1220 -810 {
lab=#net1}
N 1220 -910 1220 -860 {
lab=#net1}
N 1240 -1070 1240 -1030 {
lab=small_cycle1}
N 1440 -870 1440 -820 {
lab=#net1}
N 1440 -920 1440 -870 {
lab=#net1}
N 1460 -1080 1460 -1040 {
lab=small_cycle1}
N 1620 -870 1620 -820 {
lab=#net1}
N 1620 -920 1620 -870 {
lab=#net1}
N 1640 -1080 1640 -1040 {
lab=small_cycle1}
N 1840 -870 1840 -820 {
lab=#net1}
N 1840 -920 1840 -870 {
lab=#net1}
N 1860 -1080 1860 -1040 {
lab=small_cycle1}
N 2020 -870 2020 -820 {
lab=#net1}
N 2020 -920 2020 -870 {
lab=#net1}
N 2040 -1080 2040 -1040 {
lab=small_cycle1}
N 2240 -880 2240 -830 {
lab=#net1}
N 2240 -930 2240 -880 {
lab=#net1}
N 2260 -1090 2260 -1050 {
lab=small_cycle1}
N 2420 -880 2420 -830 {
lab=#net1}
N 2420 -930 2420 -880 {
lab=#net1}
N 2440 -1090 2440 -1050 {
lab=small_cycle1}
N 2630 -880 2630 -830 {
lab=#net1}
N 2630 -930 2630 -880 {
lab=#net1}
N 2650 -1090 2650 -1050 {
lab=small_cycle1}
N 2810 -880 2810 -830 {
lab=#net1}
N 2810 -930 2810 -880 {
lab=#net1}
N 2830 -1090 2830 -1050 {
lab=small_cycle1}
N 3030 -890 3030 -840 {
lab=#net1}
N 3030 -940 3030 -890 {
lab=#net1}
N 3050 -1100 3050 -1060 {
lab=small_cycle1}
N 3210 -890 3210 -840 {
lab=#net1}
N 3210 -940 3210 -890 {
lab=#net1}
N 3230 -1100 3230 -1060 {
lab=small_cycle1}
N 3460 -890 3460 -840 {
lab=#net1}
N 3460 -940 3460 -890 {
lab=#net1}
N 3480 -1100 3480 -1060 {
lab=small_cycle1}
N 3640 -890 3640 -840 {
lab=#net1}
N 3640 -940 3640 -890 {
lab=#net1}
N 3660 -1100 3660 -1060 {
lab=small_cycle1}
N 3860 -900 3860 -850 {
lab=#net1}
N 3860 -950 3860 -900 {
lab=#net1}
N 3880 -1110 3880 -1070 {
lab=small_cycle1}
N 4040 -900 4040 -850 {
lab=#net1}
N 4040 -950 4040 -900 {
lab=#net1}
N 4060 -1110 4060 -1070 {
lab=small_cycle1}
N 4250 -900 4250 -850 {
lab=#net1}
N 4250 -950 4250 -900 {
lab=#net1}
N 4270 -1110 4270 -1070 {
lab=small_cycle1}
N 4430 -900 4430 -850 {
lab=#net1}
N 4430 -950 4430 -900 {
lab=#net1}
N 4450 -1110 4450 -1070 {
lab=small_cycle1}
N 4650 -910 4650 -860 {
lab=#net1}
N 4650 -960 4650 -910 {
lab=#net1}
N 4670 -1120 4670 -1080 {
lab=small_cycle1}
N 4830 -910 4830 -860 {
lab=#net1}
N 4830 -960 4830 -910 {
lab=#net1}
N 4850 -1120 4850 -1080 {
lab=small_cycle1}
N 5050 -910 5050 -860 {
lab=#net1}
N 5050 -960 5050 -910 {
lab=#net1}
N 5070 -1120 5070 -1080 {
lab=small_cycle1}
N 5230 -910 5230 -860 {
lab=#net1}
N 5230 -960 5230 -910 {
lab=#net1}
N 5250 -1120 5250 -1080 {
lab=small_cycle1}
N 5450 -920 5450 -870 {
lab=#net1}
N 5450 -970 5450 -920 {
lab=#net1}
N 5470 -1130 5470 -1090 {
lab=small_cycle1}
N 5630 -920 5630 -870 {
lab=#net1}
N 5630 -970 5630 -920 {
lab=#net1}
N 5650 -1130 5650 -1090 {
lab=small_cycle1}
N 5840 -920 5840 -870 {
lab=#net1}
N 5840 -970 5840 -920 {
lab=#net1}
N 5860 -1130 5860 -1090 {
lab=small_cycle1}
N 6020 -920 6020 -870 {
lab=#net1}
N 6020 -970 6020 -920 {
lab=#net1}
N 6040 -1130 6040 -1090 {
lab=small_cycle1}
N 6240 -930 6240 -880 {
lab=#net1}
N 6240 -980 6240 -930 {
lab=#net1}
N 6260 -1140 6260 -1100 {
lab=small_cycle1}
N 90 -1160 90 -1130 {}
N 270 -1160 270 -1140 {}
N 450 -1170 450 -1140 {}
C {devices/lab_pin.sym} 2790 -480 0 0 {name=l2 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2990 -480 0 0 {name=l6 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3190 -480 0 0 {name=l7 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3390 -480 0 0 {name=l10 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3590 -480 0 0 {name=l11 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3790 -480 0 0 {name=l14 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3990 -480 0 0 {name=l15 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4190 -480 0 0 {name=l18 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4390 -480 0 0 {name=l19 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4590 -480 0 0 {name=l22 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4790 -480 0 0 {name=l23 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4990 -480 0 0 {name=l26 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5190 -480 0 0 {name=l27 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5390 -480 0 0 {name=l30 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5590 -480 0 0 {name=l31 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5790 -480 0 0 {name=l34 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5990 -480 0 0 {name=l35 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2590 -480 0 0 {name=l38 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 130 -420 0 0 {name=l39 sig_type=std_logic lab=clk_pulse}
C {devices/lab_pin.sym} 6190 -480 0 0 {name=l40 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 370 -480 0 0 {name=l215 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 570 -480 0 0 {name=l216 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 770 -480 0 0 {name=l219 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 970 -480 0 0 {name=l220 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1170 -480 0 0 {name=l223 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1370 -480 0 0 {name=l224 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1570 -480 0 0 {name=l227 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1770 -480 0 0 {name=l228 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1970 -480 0 0 {name=l231 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2170 -480 0 0 {name=l232 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2370 -480 0 0 {name=l235 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 170 -480 0 0 {name=l251 sig_type=std_logic lab=clk

}
C {devices/noconn.sym} 6400 -440 2 0 {name=l233}
C {devices/lab_pin.sym} 360 -370 0 0 {name=l131 sig_type=std_logic lab=full_cycle1
}
C {devices/lab_pin.sym} 560 -370 0 0 {name=l139 sig_type=std_logic lab=full_cycle2
}
C {devices/lab_pin.sym} 760 -370 0 0 {name=l153 sig_type=std_logic lab=full_cycle3
}
C {devices/lab_pin.sym} 960 -370 0 0 {name=l258 sig_type=std_logic lab=full_cycle4
}
C {devices/lab_pin.sym} 1160 -370 0 0 {name=l259 sig_type=std_logic lab=full_cycle5
}
C {devices/lab_pin.sym} 1360 -370 0 0 {name=l260 sig_type=std_logic lab=full_cycle6
}
C {devices/lab_pin.sym} 1560 -370 0 0 {name=l261 sig_type=std_logic lab=full_cycle7
}
C {devices/lab_pin.sym} 1760 -370 0 0 {name=l262 sig_type=std_logic lab=full_cycle8
}
C {devices/lab_pin.sym} 1960 -370 0 0 {name=l263 sig_type=std_logic lab=full_cycle9
}
C {devices/lab_pin.sym} 2160 -370 0 0 {name=l264 sig_type=std_logic lab=full_cycle10
}
C {devices/lab_pin.sym} 2360 -370 0 0 {name=l265 sig_type=std_logic lab=full_cycle11
}
C {devices/lab_pin.sym} 2560 -370 0 0 {name=l266 sig_type=std_logic lab=full_cycle12
}
C {devices/lab_pin.sym} 2780 -370 0 0 {name=l4 sig_type=std_logic lab=full_cycle13
}
C {devices/lab_pin.sym} 2980 -370 0 0 {name=l5 sig_type=std_logic lab=full_cycle14
}
C {devices/lab_pin.sym} 3180 -370 0 0 {name=l9 sig_type=std_logic lab=full_cycle15
}
C {devices/lab_pin.sym} 3380 -370 0 0 {name=l12 sig_type=std_logic lab=full_cycle16
}
C {devices/lab_pin.sym} 3580 -370 0 0 {name=l13 sig_type=std_logic lab=full_cycle17
}
C {devices/lab_pin.sym} 3780 -370 0 0 {name=l16 sig_type=std_logic lab=full_cycle18
}
C {devices/lab_pin.sym} 3980 -370 0 0 {name=l17 sig_type=std_logic lab=full_cycle19
}
C {devices/lab_pin.sym} 4180 -370 0 0 {name=l20 sig_type=std_logic lab=full_cycle20
}
C {devices/lab_pin.sym} 4380 -370 0 0 {name=l21 sig_type=std_logic lab=full_cycle21
}
C {devices/lab_pin.sym} 4580 -370 0 0 {name=l24 sig_type=std_logic lab=full_cycle22
}
C {devices/lab_pin.sym} 4780 -370 0 0 {name=l25 sig_type=std_logic lab=full_cycle23
}
C {devices/lab_pin.sym} 4980 -370 0 0 {name=l28 sig_type=std_logic lab=full_cycle24
}
C {devices/lab_pin.sym} 5180 -370 0 0 {name=l29 sig_type=std_logic lab=full_cycle25
}
C {devices/lab_pin.sym} 5380 -370 0 0 {name=l32 sig_type=std_logic lab=full_cycle26
}
C {devices/lab_pin.sym} 5580 -370 0 0 {name=l33 sig_type=std_logic lab=full_cycle27
}
C {devices/lab_pin.sym} 5780 -370 0 0 {name=l36 sig_type=std_logic lab=full_cycle28
}
C {devices/lab_pin.sym} 5980 -370 0 0 {name=l37 sig_type=std_logic lab=full_cycle29
}
C {devices/lab_pin.sym} 6180 -370 0 0 {name=l41 sig_type=std_logic lab=full_cycle30
}
C {devices/lab_pin.sym} 6400 -370 0 0 {name=l267 sig_type=std_logic lab=full_cycle31
}
C {devices/lab_pin.sym} 280 -310 2 0 {name=l268 sig_type=std_logic lab=full_cycle0
}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Dr. Aubrey Beal, Dr. Phillip Bailey, Micah Tseng"
}
C {devices/ipin.sym} 100 -130 0 0 {name=p1 lab=clk_pulse
}
C {devices/opin.sym} 150 -100 0 0 {name=p2 lab=cycle[31..0]
}
C {devices/iopin.sym} 150 -130 0 0 {name=p3 lab=VSS
}
C {devices/iopin.sym} 150 -160 0 0 {name=p4 lab=VDD
}
C {devices/ipin.sym} 100 -160 0 0 {name=p5 lab=clk
}
C {devices/lab_pin.sym} 380 -370 2 0 {name=l8 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 580 -370 2 0 {name=l49 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 780 -370 2 0 {name=l53 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 980 -370 2 0 {name=l57 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1180 -370 2 0 {name=l61 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1380 -370 2 0 {name=l65 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1580 -370 2 0 {name=l69 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1780 -370 2 0 {name=l73 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1980 -370 2 0 {name=l77 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 2180 -370 2 0 {name=l81 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 2380 -370 2 0 {name=l85 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 2600 -370 2 0 {name=l89 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3000 -370 2 0 {name=l92 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3000 -370 2 0 {name=l93 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3200 -370 2 0 {name=l97 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3400 -370 2 0 {name=l101 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3600 -370 2 0 {name=l105 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3800 -370 2 0 {name=l109 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4000 -370 2 0 {name=l113 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4200 -370 2 0 {name=l117 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4400 -370 2 0 {name=l121 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4600 -370 2 0 {name=l125 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4800 -370 2 0 {name=l129 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5000 -370 2 0 {name=l134 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5200 -370 2 0 {name=l138 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5400 -370 2 0 {name=l143 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5600 -370 2 0 {name=l147 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5800 -370 2 0 {name=l151 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 6000 -370 2 0 {name=l156 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 6200 -370 2 0 {name=l160 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 180 -360 2 0 {name=l42 sig_type=std_logic lab=reset_b
}
C {devices/ipin.sym} 100 -100 0 0 {name=p6 lab=reset_b
}
C {devices/lab_pin.sym} 2800 -370 2 0 {name=l43 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/buf_12.sym} 210 -310 0 0 {name=x33 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 270 -420 0 0 {name=x32 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 470 -420 0 0 {name=x1 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 670 -420 0 0 {name=x2 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 870 -420 0 0 {name=x3 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 1070 -420 0 0 {name=x4 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 1270 -420 0 0 {name=x5 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 1470 -420 0 0 {name=x6 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 1670 -420 0 0 {name=x7 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 1870 -420 0 0 {name=x8 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 2070 -420 0 0 {name=x9 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 2270 -420 0 0 {name=x10 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 2470 -420 0 0 {name=x11 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 2690 -420 0 0 {name=x12 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 2890 -420 0 0 {name=x13 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 3090 -420 0 0 {name=x14 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 3290 -420 0 0 {name=x15 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 3490 -420 0 0 {name=x16 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 3690 -420 0 0 {name=x17 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 3890 -420 0 0 {name=x18 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 4090 -420 0 0 {name=x19 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 4290 -420 0 0 {name=x20 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 4490 -420 0 0 {name=x21 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 4690 -420 0 0 {name=x22 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 4890 -420 0 0 {name=x23 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 5090 -420 0 0 {name=x24 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 5290 -420 0 0 {name=x25 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 5490 -420 0 0 {name=x26 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 5690 -420 0 0 {name=x27 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 5890 -420 0 0 {name=x28 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 6090 -420 0 0 {name=x29 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 6290 -420 0 0 {name=x30 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 90 -700 3 0 {name=x35 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 70 -610 3 0 {name=l162 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 110 -610 3 0 {name=l165 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 90 -950 3 0 {name=x36 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 90 -1160 1 0 {name=l166 sig_type=std_logic lab=cycle0
}
C {devices/lab_pin.sym} 90 -610 3 0 {name=l167 sig_type=std_logic lab=full_cycle0
}
C {devices/lab_pin.sym} 110 -890 3 0 {name=l168 sig_type=std_logic lab=full_cycle0
}
C {devices/lab_pin.sym} 370 -480 0 0 {name=l184 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 570 -480 0 0 {name=l185 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 770 -480 0 0 {name=l186 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 970 -480 0 0 {name=l187 sig_type=std_logic lab=clk

}
C {sky130_stdcells/dfrtp_1.sym} 270 -710 3 0 {name=x39 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 250 -620 3 0 {name=l171 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 290 -620 3 0 {name=l172 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 270 -960 3 0 {name=x40 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 270 -1160 1 0 {name=l173 sig_type=std_logic lab=cycle1
}
C {devices/lab_pin.sym} 270 -620 3 0 {name=l174 sig_type=std_logic lab=full_cycle1
}
C {devices/lab_pin.sym} 290 -900 3 0 {name=l175 sig_type=std_logic lab=full_cycle1
}
C {sky130_stdcells/dfrtp_1.sym} 450 -710 3 0 {name=x31 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 430 -620 3 0 {name=l3 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 470 -620 3 0 {name=l44 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 450 -960 3 0 {name=x34 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 450 -1170 1 0 {name=l45 sig_type=std_logic lab=cycle2
}
C {devices/lab_pin.sym} 450 -620 3 0 {name=l46 sig_type=std_logic lab=full_cycle2
}
C {devices/lab_pin.sym} 470 -900 3 0 {name=l47 sig_type=std_logic lab=full_cycle2
}
C {sky130_stdcells/dfrtp_1.sym} 670 -720 3 0 {name=x37 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 650 -630 3 0 {name=l48 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 690 -630 3 0 {name=l50 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 670 -970 3 0 {name=x38 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 670 -1070 1 0 {name=l51 sig_type=std_logic lab=cycle3
}
C {devices/lab_pin.sym} 670 -630 3 0 {name=l52 sig_type=std_logic lab=full_cycle3
}
C {devices/lab_pin.sym} 690 -910 3 0 {name=l54 sig_type=std_logic lab=full_cycle3
}
C {sky130_stdcells/dfrtp_1.sym} 850 -720 3 0 {name=x41 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 830 -630 3 0 {name=l55 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 870 -630 3 0 {name=l56 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 850 -970 3 0 {name=x42 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 850 -1070 1 0 {name=l58 sig_type=std_logic lab=cycle4
}
C {devices/lab_pin.sym} 850 -630 3 0 {name=l59 sig_type=std_logic lab=full_cycle4
}
C {devices/lab_pin.sym} 870 -910 3 0 {name=l60 sig_type=std_logic lab=full_cycle4
}
C {sky130_stdcells/dfrtp_1.sym} 1060 -720 3 0 {name=x43 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1040 -630 3 0 {name=l62 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1080 -630 3 0 {name=l63 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 1060 -970 3 0 {name=x44 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1060 -1070 1 0 {name=l64 sig_type=std_logic lab=cycle5
}
C {devices/lab_pin.sym} 1060 -630 3 0 {name=l66 sig_type=std_logic lab=full_cycle5
}
C {devices/lab_pin.sym} 1080 -910 3 0 {name=l67 sig_type=std_logic lab=full_cycle5
}
C {sky130_stdcells/dfrtp_1.sym} 1240 -720 3 0 {name=x45 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1220 -630 3 0 {name=l68 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1260 -630 3 0 {name=l70 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 1240 -970 3 0 {name=x46 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1240 -1070 1 0 {name=l71 sig_type=std_logic lab=cycle6
}
C {devices/lab_pin.sym} 1240 -630 3 0 {name=l72 sig_type=std_logic lab=full_cycle6
}
C {devices/lab_pin.sym} 1260 -910 3 0 {name=l74 sig_type=std_logic lab=full_cycle6
}
C {sky130_stdcells/dfrtp_1.sym} 1460 -730 3 0 {name=x47 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1440 -640 3 0 {name=l75 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1480 -640 3 0 {name=l76 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 1460 -980 3 0 {name=x48 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1460 -1080 1 0 {name=l78 sig_type=std_logic lab=cycle7
}
C {devices/lab_pin.sym} 1460 -640 3 0 {name=l79 sig_type=std_logic lab=full_cycle7
}
C {devices/lab_pin.sym} 1480 -920 3 0 {name=l80 sig_type=std_logic lab=full_cycle7
}
C {sky130_stdcells/dfrtp_1.sym} 1640 -730 3 0 {name=x49 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1620 -640 3 0 {name=l82 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1660 -640 3 0 {name=l83 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 1640 -980 3 0 {name=x50 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1640 -1080 1 0 {name=l84 sig_type=std_logic lab=cycle8
}
C {devices/lab_pin.sym} 1640 -640 3 0 {name=l86 sig_type=std_logic lab=full_cycle8
}
C {devices/lab_pin.sym} 1660 -920 3 0 {name=l87 sig_type=std_logic lab=full_cycle8
}
C {sky130_stdcells/dfrtp_1.sym} 1860 -730 3 0 {name=x51 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1840 -640 3 0 {name=l88 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1880 -640 3 0 {name=l90 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 1860 -980 3 0 {name=x52 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1860 -1080 1 0 {name=l91 sig_type=std_logic lab=cycle9
}
C {devices/lab_pin.sym} 1860 -640 3 0 {name=l94 sig_type=std_logic lab=full_cycle9
}
C {devices/lab_pin.sym} 1880 -920 3 0 {name=l95 sig_type=std_logic lab=full_cycle9
}
C {sky130_stdcells/dfrtp_1.sym} 2040 -730 3 0 {name=x53 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2020 -640 3 0 {name=l96 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2060 -640 3 0 {name=l98 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 2040 -980 3 0 {name=x54 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2040 -1080 1 0 {name=l99 sig_type=std_logic lab=cycle10
}
C {devices/lab_pin.sym} 2040 -640 3 0 {name=l100 sig_type=std_logic lab=full_cycle10
}
C {devices/lab_pin.sym} 2060 -920 3 0 {name=l102 sig_type=std_logic lab=full_cycle10
}
C {sky130_stdcells/dfrtp_1.sym} 2260 -740 3 0 {name=x55 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2240 -650 3 0 {name=l103 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2280 -650 3 0 {name=l104 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 2260 -990 3 0 {name=x56 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2260 -1090 1 0 {name=l106 sig_type=std_logic lab=cycle11
}
C {devices/lab_pin.sym} 2260 -650 3 0 {name=l107 sig_type=std_logic lab=full_cycle11
}
C {devices/lab_pin.sym} 2280 -930 3 0 {name=l108 sig_type=std_logic lab=full_cycle11
}
C {sky130_stdcells/dfrtp_1.sym} 2440 -740 3 0 {name=x57 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2420 -650 3 0 {name=l110 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2460 -650 3 0 {name=l111 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 2440 -990 3 0 {name=x58 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2440 -1090 1 0 {name=l112 sig_type=std_logic lab=cycle12
}
C {devices/lab_pin.sym} 2440 -650 3 0 {name=l114 sig_type=std_logic lab=full_cycle12
}
C {devices/lab_pin.sym} 2460 -930 3 0 {name=l115 sig_type=std_logic lab=full_cycle12
}
C {sky130_stdcells/dfrtp_1.sym} 2650 -740 3 0 {name=x59 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2630 -650 3 0 {name=l116 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2670 -650 3 0 {name=l118 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 2650 -990 3 0 {name=x60 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2650 -1090 1 0 {name=l119 sig_type=std_logic lab=cycle13
}
C {devices/lab_pin.sym} 2650 -650 3 0 {name=l120 sig_type=std_logic lab=full_cycle13
}
C {devices/lab_pin.sym} 2670 -930 3 0 {name=l122 sig_type=std_logic lab=full_cycle13
}
C {sky130_stdcells/dfrtp_1.sym} 2830 -740 3 0 {name=x61 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2810 -650 3 0 {name=l123 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2850 -650 3 0 {name=l124 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 2830 -990 3 0 {name=x62 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2830 -1090 1 0 {name=l126 sig_type=std_logic lab=cycle14
}
C {devices/lab_pin.sym} 2830 -650 3 0 {name=l127 sig_type=std_logic lab=full_cycle14
}
C {devices/lab_pin.sym} 2850 -930 3 0 {name=l128 sig_type=std_logic lab=full_cycle14
}
C {sky130_stdcells/dfrtp_1.sym} 3050 -750 3 0 {name=x63 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3030 -660 3 0 {name=l130 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3070 -660 3 0 {name=l132 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 3050 -1000 3 0 {name=x64 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3050 -1100 1 0 {name=l133 sig_type=std_logic lab=cycle15
}
C {devices/lab_pin.sym} 3050 -660 3 0 {name=l135 sig_type=std_logic lab=full_cycle15
}
C {devices/lab_pin.sym} 3070 -940 3 0 {name=l136 sig_type=std_logic lab=full_cycle15
}
C {sky130_stdcells/dfrtp_1.sym} 3230 -750 3 0 {name=x65 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3210 -660 3 0 {name=l137 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3250 -660 3 0 {name=l140 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 3230 -1000 3 0 {name=x66 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3230 -1100 1 0 {name=l141 sig_type=std_logic lab=cycle16
}
C {devices/lab_pin.sym} 3230 -660 3 0 {name=l142 sig_type=std_logic lab=full_cycle16
}
C {devices/lab_pin.sym} 3250 -940 3 0 {name=l144 sig_type=std_logic lab=full_cycle16
}
C {sky130_stdcells/dfrtp_1.sym} 3480 -750 3 0 {name=x67 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3460 -660 3 0 {name=l145 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3500 -660 3 0 {name=l146 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 3480 -1000 3 0 {name=x68 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3480 -1100 1 0 {name=l148 sig_type=std_logic lab=cycle17
}
C {devices/lab_pin.sym} 3480 -660 3 0 {name=l149 sig_type=std_logic lab=full_cycle17
}
C {devices/lab_pin.sym} 3500 -940 3 0 {name=l150 sig_type=std_logic lab=full_cycle17
}
C {sky130_stdcells/dfrtp_1.sym} 3660 -750 3 0 {name=x69 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3640 -660 3 0 {name=l152 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3680 -660 3 0 {name=l154 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 3660 -1000 3 0 {name=x70 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3660 -1100 1 0 {name=l155 sig_type=std_logic lab=cycle18
}
C {devices/lab_pin.sym} 3660 -660 3 0 {name=l157 sig_type=std_logic lab=full_cycle18
}
C {devices/lab_pin.sym} 3680 -940 3 0 {name=l158 sig_type=std_logic lab=full_cycle18
}
C {sky130_stdcells/dfrtp_1.sym} 3880 -760 3 0 {name=x71 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3860 -670 3 0 {name=l159 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3900 -670 3 0 {name=l161 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 3880 -1010 3 0 {name=x72 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3880 -1110 1 0 {name=l163 sig_type=std_logic lab=cycle19
}
C {devices/lab_pin.sym} 3880 -670 3 0 {name=l164 sig_type=std_logic lab=full_cycle19
}
C {devices/lab_pin.sym} 3900 -950 3 0 {name=l169 sig_type=std_logic lab=full_cycle19
}
C {sky130_stdcells/dfrtp_1.sym} 4060 -760 3 0 {name=x73 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4040 -670 3 0 {name=l170 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4080 -670 3 0 {name=l176 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 4060 -1010 3 0 {name=x74 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4060 -1110 1 0 {name=l177 sig_type=std_logic lab=cycle20
}
C {devices/lab_pin.sym} 4060 -670 3 0 {name=l178 sig_type=std_logic lab=full_cycle20
}
C {devices/lab_pin.sym} 4080 -950 3 0 {name=l179 sig_type=std_logic lab=full_cycle20
}
C {sky130_stdcells/dfrtp_1.sym} 4270 -760 3 0 {name=x75 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4250 -670 3 0 {name=l180 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4290 -670 3 0 {name=l181 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 4270 -1010 3 0 {name=x76 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4270 -1110 1 0 {name=l182 sig_type=std_logic lab=cycle21
}
C {devices/lab_pin.sym} 4270 -670 3 0 {name=l183 sig_type=std_logic lab=full_cycle21
}
C {devices/lab_pin.sym} 4290 -950 3 0 {name=l188 sig_type=std_logic lab=full_cycle21
}
C {sky130_stdcells/dfrtp_1.sym} 4450 -760 3 0 {name=x77 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4430 -670 3 0 {name=l189 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4470 -670 3 0 {name=l190 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 4450 -1010 3 0 {name=x78 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4450 -1110 1 0 {name=l191 sig_type=std_logic lab=cycle22
}
C {devices/lab_pin.sym} 4450 -670 3 0 {name=l192 sig_type=std_logic lab=full_cycle22
}
C {devices/lab_pin.sym} 4470 -950 3 0 {name=l193 sig_type=std_logic lab=full_cycle22
}
C {sky130_stdcells/dfrtp_1.sym} 4670 -770 3 0 {name=x79 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4650 -680 3 0 {name=l194 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4690 -680 3 0 {name=l195 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 4670 -1020 3 0 {name=x80 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4670 -1120 1 0 {name=l196 sig_type=std_logic lab=cycle23
}
C {devices/lab_pin.sym} 4670 -680 3 0 {name=l197 sig_type=std_logic lab=full_cycle23
}
C {devices/lab_pin.sym} 4690 -960 3 0 {name=l198 sig_type=std_logic lab=full_cycle23
}
C {sky130_stdcells/dfrtp_1.sym} 4850 -770 3 0 {name=x81 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4830 -680 3 0 {name=l199 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4870 -680 3 0 {name=l200 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 4850 -1020 3 0 {name=x82 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 4850 -1120 1 0 {name=l201 sig_type=std_logic lab=cycle24
}
C {devices/lab_pin.sym} 4850 -680 3 0 {name=l202 sig_type=std_logic lab=full_cycle24
}
C {devices/lab_pin.sym} 4870 -960 3 0 {name=l203 sig_type=std_logic lab=full_cycle24
}
C {sky130_stdcells/dfrtp_1.sym} 5070 -770 3 0 {name=x83 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5050 -680 3 0 {name=l204 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5090 -680 3 0 {name=l205 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 5070 -1020 3 0 {name=x84 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5070 -1120 1 0 {name=l206 sig_type=std_logic lab=cycle25
}
C {devices/lab_pin.sym} 5070 -680 3 0 {name=l207 sig_type=std_logic lab=full_cycle25
}
C {devices/lab_pin.sym} 5090 -960 3 0 {name=l208 sig_type=std_logic lab=full_cycle25
}
C {sky130_stdcells/dfrtp_1.sym} 5250 -770 3 0 {name=x85 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5230 -680 3 0 {name=l209 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5270 -680 3 0 {name=l210 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 5250 -1020 3 0 {name=x86 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5250 -1120 1 0 {name=l211 sig_type=std_logic lab=cycle26
}
C {devices/lab_pin.sym} 5250 -680 3 0 {name=l212 sig_type=std_logic lab=full_cycle26
}
C {devices/lab_pin.sym} 5270 -960 3 0 {name=l213 sig_type=std_logic lab=full_cycle26
}
C {sky130_stdcells/dfrtp_1.sym} 5470 -780 3 0 {name=x87 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5450 -690 3 0 {name=l214 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5490 -690 3 0 {name=l217 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 5470 -1030 3 0 {name=x88 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5470 -1130 1 0 {name=l218 sig_type=std_logic lab=cycle27
}
C {devices/lab_pin.sym} 5470 -690 3 0 {name=l221 sig_type=std_logic lab=full_cycle27
}
C {devices/lab_pin.sym} 5490 -970 3 0 {name=l222 sig_type=std_logic lab=full_cycle27
}
C {sky130_stdcells/dfrtp_1.sym} 5650 -780 3 0 {name=x89 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5630 -690 3 0 {name=l225 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5670 -690 3 0 {name=l226 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 5650 -1030 3 0 {name=x90 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5650 -1130 1 0 {name=l229 sig_type=std_logic lab=cycle28
}
C {devices/lab_pin.sym} 5650 -690 3 0 {name=l230 sig_type=std_logic lab=full_cycle28
}
C {devices/lab_pin.sym} 5670 -970 3 0 {name=l234 sig_type=std_logic lab=full_cycle28
}
C {sky130_stdcells/dfrtp_1.sym} 5860 -780 3 0 {name=x91 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5840 -690 3 0 {name=l236 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5880 -690 3 0 {name=l237 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 5860 -1030 3 0 {name=x92 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 5860 -1130 1 0 {name=l238 sig_type=std_logic lab=cycle29
}
C {devices/lab_pin.sym} 5860 -690 3 0 {name=l239 sig_type=std_logic lab=full_cycle29
}
C {devices/lab_pin.sym} 5880 -970 3 0 {name=l240 sig_type=std_logic lab=full_cycle29
}
C {sky130_stdcells/dfrtp_1.sym} 6040 -780 3 0 {name=x93 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 6020 -690 3 0 {name=l241 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 6060 -690 3 0 {name=l242 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 6040 -1030 3 0 {name=x94 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 6040 -1130 1 0 {name=l243 sig_type=std_logic lab=cycle30
}
C {devices/lab_pin.sym} 6040 -690 3 0 {name=l244 sig_type=std_logic lab=full_cycle30
}
C {devices/lab_pin.sym} 6060 -970 3 0 {name=l245 sig_type=std_logic lab=full_cycle30
}
C {sky130_stdcells/dfrtp_1.sym} 6260 -790 3 0 {name=x95 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 6240 -700 3 0 {name=l246 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 6280 -700 3 0 {name=l247 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/and2_0.sym} 6260 -1040 3 0 {name=x96 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 6260 -1140 1 0 {name=l248 sig_type=std_logic lab=cycle31
}
C {devices/lab_pin.sym} 6260 -700 3 0 {name=l249 sig_type=std_logic lab=full_cycle31
}
C {devices/lab_pin.sym} 6280 -980 3 0 {name=l250 sig_type=std_logic lab=full_cycle31
}
C {sky130_stdcells/clkbuf_4.sym} 90 -1090 3 0 {name=x97 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/clkbuf_4.sym} 270 -1100 3 0 {name=x98 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/clkbuf_4.sym} 450 -1100 3 0 {name=x99 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
