v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 2930 -390 2940 -390 {
lab=clk}
N 2940 -390 2940 -350 {
lab=clk}
N 3130 -390 3140 -390 {
lab=clk}
N 3140 -390 3140 -350 {
lab=clk}
N 3330 -390 3340 -390 {
lab=clk}
N 3340 -390 3340 -350 {
lab=clk}
N 3530 -390 3540 -390 {
lab=clk}
N 3540 -390 3540 -350 {
lab=clk}
N 3730 -390 3740 -390 {
lab=clk}
N 3740 -390 3740 -350 {
lab=clk}
N 3930 -390 3940 -390 {
lab=clk}
N 3940 -390 3940 -350 {
lab=clk}
N 4130 -390 4140 -390 {
lab=clk}
N 4140 -390 4140 -350 {
lab=clk}
N 4330 -390 4340 -390 {
lab=clk}
N 4340 -390 4340 -350 {
lab=clk}
N 4530 -390 4540 -390 {
lab=clk}
N 4540 -390 4540 -350 {
lab=clk}
N 4730 -390 4740 -390 {
lab=clk}
N 4740 -390 4740 -350 {
lab=clk}
N 4930 -390 4940 -390 {
lab=clk}
N 4940 -390 4940 -350 {
lab=clk}
N 5130 -390 5140 -390 {
lab=clk}
N 5140 -390 5140 -350 {
lab=clk}
N 5330 -390 5340 -390 {
lab=clk}
N 5340 -390 5340 -350 {
lab=clk}
N 5530 -390 5540 -390 {
lab=clk}
N 5540 -390 5540 -350 {
lab=clk}
N 5730 -390 5740 -390 {
lab=clk}
N 5740 -390 5740 -350 {
lab=clk}
N 5930 -390 5940 -390 {
lab=clk}
N 5940 -390 5940 -350 {
lab=clk}
N 6130 -390 6140 -390 {
lab=clk}
N 6140 -390 6140 -350 {
lab=clk}
N 2730 -390 2740 -390 {
lab=clk}
N 2740 -390 2740 -350 {
lab=clk}
N 6330 -390 6340 -390 {
lab=clk}
N 6340 -390 6340 -350 {
lab=clk}
N 6520 -350 6540 -350 {
lab=cycle31}
N 500 -350 500 -330 {
lab=cycle1}
N 500 -330 520 -330 {
lab=cycle1}
N 520 -390 520 -350 {
lab=clk}
N 720 -390 720 -350 {
lab=clk}
N 920 -390 920 -350 {
lab=clk}
N 1120 -390 1120 -350 {
lab=clk}
N 1310 -390 1320 -390 {
lab=clk}
N 1320 -390 1320 -350 {
lab=clk}
N 1510 -390 1520 -390 {
lab=clk}
N 1520 -390 1520 -350 {
lab=clk}
N 1710 -390 1720 -390 {
lab=clk}
N 1720 -390 1720 -350 {
lab=clk}
N 1910 -390 1920 -390 {
lab=clk}
N 1920 -390 1920 -350 {
lab=clk}
N 2110 -390 2120 -390 {
lab=clk}
N 2120 -390 2120 -350 {
lab=clk}
N 2310 -390 2320 -390 {
lab=clk}
N 2320 -390 2320 -350 {
lab=clk}
N 2510 -390 2520 -390 {
lab=clk}
N 2520 -390 2520 -350 {
lab=clk}
N 310 -390 320 -390 {
lab=clk}
N 320 -390 320 -350 {
lab=clk}
N 310 -330 320 -330 {
lab=cycle0}
N 6540 -350 6540 -300 {
lab=cycle31}
N 500 -330 500 -280 {
lab=cycle1}
N 520 -310 520 -280 {
lab=reset_b}
N 520 -310 520 -280 {
lab=reset_b}
N 720 -310 720 -280 {
lab=reset_b}
N 720 -310 720 -280 {
lab=reset_b}
N 920 -310 920 -280 {
lab=reset_b}
N 920 -310 920 -280 {
lab=reset_b}
N 1120 -310 1120 -280 {
lab=reset_b}
N 1120 -310 1120 -280 {
lab=reset_b}
N 1320 -310 1320 -280 {
lab=reset_b}
N 1320 -310 1320 -280 {
lab=reset_b}
N 1520 -310 1520 -280 {
lab=reset_b}
N 1520 -310 1520 -280 {
lab=reset_b}
N 1720 -310 1720 -280 {
lab=reset_b}
N 1720 -310 1720 -280 {
lab=reset_b}
N 1920 -310 1920 -280 {
lab=reset_b}
N 1920 -310 1920 -280 {
lab=reset_b}
N 2120 -310 2120 -280 {
lab=reset_b}
N 2120 -310 2120 -280 {
lab=reset_b}
N 2320 -310 2320 -280 {
lab=reset_b}
N 2320 -310 2320 -280 {
lab=reset_b}
N 2520 -310 2520 -280 {
lab=reset_b}
N 2520 -310 2520 -280 {
lab=reset_b}
N 2740 -310 2740 -280 {
lab=reset_b}
N 2740 -310 2740 -280 {
lab=reset_b}
N 3140 -310 3140 -280 {
lab=reset_b}
N 3140 -310 3140 -280 {
lab=reset_b}
N 3340 -310 3340 -280 {
lab=reset_b}
N 3340 -310 3340 -280 {
lab=reset_b}
N 3540 -310 3540 -280 {
lab=reset_b}
N 3540 -310 3540 -280 {
lab=reset_b}
N 3740 -310 3740 -280 {
lab=reset_b}
N 3740 -310 3740 -280 {
lab=reset_b}
N 3940 -310 3940 -280 {
lab=reset_b}
N 3940 -310 3940 -280 {
lab=reset_b}
N 4140 -310 4140 -280 {
lab=reset_b}
N 4140 -310 4140 -280 {
lab=reset_b}
N 4340 -310 4340 -280 {
lab=reset_b}
N 4340 -310 4340 -280 {
lab=reset_b}
N 4540 -310 4540 -280 {
lab=reset_b}
N 4540 -310 4540 -280 {
lab=reset_b}
N 4740 -310 4740 -280 {
lab=reset_b}
N 4740 -310 4740 -280 {
lab=reset_b}
N 4940 -310 4940 -280 {
lab=reset_b}
N 4940 -310 4940 -280 {
lab=reset_b}
N 5140 -310 5140 -280 {
lab=reset_b}
N 5140 -310 5140 -280 {
lab=reset_b}
N 5340 -310 5340 -280 {
lab=reset_b}
N 5340 -310 5340 -280 {
lab=reset_b}
N 5540 -310 5540 -280 {
lab=reset_b}
N 5540 -310 5540 -280 {
lab=reset_b}
N 5740 -310 5740 -280 {
lab=reset_b}
N 5740 -310 5740 -280 {
lab=reset_b}
N 5940 -310 5940 -280 {
lab=reset_b}
N 5940 -310 5940 -280 {
lab=reset_b}
N 6140 -310 6140 -280 {
lab=reset_b}
N 6140 -310 6140 -280 {
lab=reset_b}
N 6340 -310 6340 -280 {
lab=reset_b}
N 6340 -310 6340 -280 {
lab=reset_b}
N 700 -350 700 -280 {
lab=cycle2}
N 700 -330 720 -330 {
lab=cycle2}
N 900 -350 900 -280 {
lab=cycle3}
N 900 -330 920 -330 {
lab=cycle3}
N 1100 -350 1100 -280 {
lab=cycle4}
N 1100 -330 1120 -330 {
lab=cycle4}
N 1300 -350 1300 -280 {
lab=cycle5}
N 1300 -330 1320 -330 {
lab=cycle5}
N 1500 -350 1500 -280 {
lab=cycle6}
N 1500 -330 1520 -330 {
lab=cycle6}
N 1700 -350 1700 -280 {
lab=cycle7}
N 1700 -330 1720 -330 {
lab=cycle7}
N 1900 -350 1900 -280 {
lab=cycle8}
N 1900 -330 1920 -330 {
lab=cycle8}
N 2100 -350 2100 -280 {
lab=cycle9}
N 2100 -330 2120 -330 {
lab=cycle9}
N 2300 -350 2300 -280 {
lab=cycle10}
N 2300 -330 2320 -330 {
lab=cycle10}
N 2500 -350 2500 -280 {
lab=cycle11}
N 2500 -330 2520 -330 {
lab=cycle11}
N 2700 -350 2700 -280 {
lab=cycle12}
N 2700 -330 2740 -330 {
lab=cycle12}
N 2920 -350 2920 -280 {
lab=cycle13}
N 2920 -330 2940 -330 {
lab=cycle13}
N 3120 -350 3120 -280 {
lab=cycle14}
N 3120 -330 3140 -330 {
lab=cycle14}
N 3320 -350 3320 -280 {
lab=cycle15}
N 3320 -330 3340 -330 {
lab=cycle15}
N 3520 -330 3540 -330 {
lab=cycle16}
N 3520 -350 3520 -280 {
lab=cycle16}
N 3720 -350 3720 -280 {
lab=cycle17}
N 3720 -330 3740 -330 {
lab=cycle17}
N 3920 -350 3920 -280 {
lab=cycle18}
N 3920 -330 3940 -330 {
lab=cycle18}
N 4120 -350 4120 -280 {
lab=cycle19}
N 4120 -330 4140 -330 {
lab=cycle19}
N 4320 -350 4320 -280 {
lab=cycle20}
N 4320 -330 4340 -330 {
lab=cycle20}
N 4520 -350 4520 -280 {
lab=cycle21}
N 4520 -330 4540 -330 {
lab=cycle21}
N 4720 -350 4720 -280 {
lab=cycle22}
N 4720 -330 4740 -330 {
lab=cycle22}
N 4920 -350 4920 -280 {
lab=cycle23}
N 4920 -330 4940 -330 {
lab=cycle23}
N 5120 -350 5120 -280 {
lab=cycle24}
N 5120 -330 5140 -330 {
lab=cycle24}
N 5320 -350 5320 -280 {
lab=cycle25}
N 5320 -330 5340 -330 {
lab=cycle25}
N 5520 -350 5520 -280 {
lab=cycle26}
N 5520 -330 5540 -330 {
lab=cycle26}
N 5720 -350 5720 -280 {
lab=cycle27}
N 5720 -330 5740 -330 {
lab=cycle27}
N 5920 -350 5920 -280 {
lab=cycle28}
N 5920 -330 5940 -330 {
lab=cycle28}
N 6120 -350 6120 -280 {
lab=cycle29}
N 6120 -330 6140 -330 {
lab=cycle29}
N 6320 -350 6320 -280 {
lab=cycle30}
N 6540 -300 6540 -280 {
lab=cycle31}
N 270 -330 310 -330 {
lab=cycle0}
N 320 -310 320 -270 {
lab=reset_b}
N 2940 -310 2940 -280 {
lab=reset_b}
N 6320 -330 6340 -330 {
lab=cycle30}
N 510 -390 520 -390 {
lab=clk}
N 910 -390 920 -390 {
lab=clk}
N 1110 -390 1120 -390 {
lab=clk}
N 710 -390 720 -390 {
lab=clk}
N 270 -350 270 -330 {
lab=cycle0}
N 80 -390 90 -390 {
lab=clk}
N 90 -390 90 -350 {
lab=clk}
N 80 -330 90 -330 {
lab=VDD}
N 270 -330 270 -280 {
lab=cycle0}
N 90 -310 90 -270 {
lab=reset_b}
N 610 -150 620 -150 {
lab=reset_b}
N 380 -170 390 -170 {
lab=reset_cycle}
N 380 -130 390 -130 {
lab=reset}
N 510 -150 530 -150 {
lab=#net1}
N 6550 -390 6560 -390 {
lab=clk}
N 6560 -390 6560 -350 {
lab=clk}
N 6740 -350 6760 -350 {
lab=cycle31}
N 6760 -350 6760 -300 {
lab=cycle31}
N 6560 -310 6560 -280 {
lab=reset_b}
N 6560 -310 6560 -280 {
lab=reset_b}
N 6760 -300 6760 -280 {
lab=cycle31}
N 6540 -330 6560 -330 {
lab=cycle30}
N 880 -150 890 -150 {}
N 880 -110 890 -110 {}
N 1010 -130 1020 -130 {}
C {devices/lab_pin.sym} 2930 -390 0 0 {name=l2 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3130 -390 0 0 {name=l6 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3330 -390 0 0 {name=l7 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3530 -390 0 0 {name=l10 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3730 -390 0 0 {name=l11 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 3930 -390 0 0 {name=l14 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4130 -390 0 0 {name=l15 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4330 -390 0 0 {name=l18 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4530 -390 0 0 {name=l19 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4730 -390 0 0 {name=l22 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 4930 -390 0 0 {name=l23 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5130 -390 0 0 {name=l26 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5330 -390 0 0 {name=l27 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5530 -390 0 0 {name=l30 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5730 -390 0 0 {name=l31 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 5930 -390 0 0 {name=l34 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 6130 -390 0 0 {name=l35 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2730 -390 0 0 {name=l38 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 80 -330 0 0 {name=l39 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} 6330 -390 0 0 {name=l40 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 510 -390 0 0 {name=l215 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 710 -390 0 0 {name=l216 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 910 -390 0 0 {name=l219 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1110 -390 0 0 {name=l220 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1310 -390 0 0 {name=l223 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1510 -390 0 0 {name=l224 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1710 -390 0 0 {name=l227 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1910 -390 0 0 {name=l228 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2110 -390 0 0 {name=l231 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2310 -390 0 0 {name=l232 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 2510 -390 0 0 {name=l235 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 310 -390 0 0 {name=l251 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 500 -280 0 0 {name=l131 sig_type=std_logic lab=cycle1
}
C {devices/lab_pin.sym} 700 -280 0 0 {name=l139 sig_type=std_logic lab=cycle2
}
C {devices/lab_pin.sym} 900 -280 0 0 {name=l153 sig_type=std_logic lab=cycle3
}
C {devices/lab_pin.sym} 1100 -280 0 0 {name=l258 sig_type=std_logic lab=cycle4
}
C {devices/lab_pin.sym} 1300 -280 0 0 {name=l259 sig_type=std_logic lab=cycle5
}
C {devices/lab_pin.sym} 1500 -280 0 0 {name=l260 sig_type=std_logic lab=cycle6
}
C {devices/lab_pin.sym} 1700 -280 0 0 {name=l261 sig_type=std_logic lab=cycle7
}
C {devices/lab_pin.sym} 1900 -280 0 0 {name=l262 sig_type=std_logic lab=cycle8
}
C {devices/lab_pin.sym} 2100 -280 0 0 {name=l263 sig_type=std_logic lab=cycle9
}
C {devices/lab_pin.sym} 2300 -280 0 0 {name=l264 sig_type=std_logic lab=cycle10
}
C {devices/lab_pin.sym} 2500 -280 0 0 {name=l265 sig_type=std_logic lab=cycle11
}
C {devices/lab_pin.sym} 2700 -280 0 0 {name=l266 sig_type=std_logic lab=cycle12
}
C {devices/lab_pin.sym} 2920 -280 0 0 {name=l4 sig_type=std_logic lab=cycle13
}
C {devices/lab_pin.sym} 3120 -280 0 0 {name=l5 sig_type=std_logic lab=cycle14
}
C {devices/lab_pin.sym} 3320 -280 0 0 {name=l9 sig_type=std_logic lab=cycle15
}
C {devices/lab_pin.sym} 3520 -280 0 0 {name=l12 sig_type=std_logic lab=cycle16
}
C {devices/lab_pin.sym} 3720 -280 0 0 {name=l13 sig_type=std_logic lab=cycle17
}
C {devices/lab_pin.sym} 3920 -280 0 0 {name=l16 sig_type=std_logic lab=cycle18
}
C {devices/lab_pin.sym} 4120 -280 0 0 {name=l17 sig_type=std_logic lab=cycle19
}
C {devices/lab_pin.sym} 4320 -280 0 0 {name=l20 sig_type=std_logic lab=cycle20
}
C {devices/lab_pin.sym} 4520 -280 0 0 {name=l21 sig_type=std_logic lab=cycle21
}
C {devices/lab_pin.sym} 4720 -280 0 0 {name=l24 sig_type=std_logic lab=cycle22
}
C {devices/lab_pin.sym} 4920 -280 0 0 {name=l25 sig_type=std_logic lab=cycle23
}
C {devices/lab_pin.sym} 5120 -280 0 0 {name=l28 sig_type=std_logic lab=cycle24
}
C {devices/lab_pin.sym} 5320 -280 0 0 {name=l29 sig_type=std_logic lab=cycle25
}
C {devices/lab_pin.sym} 5520 -280 0 0 {name=l32 sig_type=std_logic lab=cycle26
}
C {devices/lab_pin.sym} 5720 -280 0 0 {name=l33 sig_type=std_logic lab=cycle27
}
C {devices/lab_pin.sym} 5920 -280 0 0 {name=l36 sig_type=std_logic lab=cycle28
}
C {devices/lab_pin.sym} 6120 -280 0 0 {name=l37 sig_type=std_logic lab=cycle29
}
C {devices/lab_pin.sym} 6320 -280 0 0 {name=l41 sig_type=std_logic lab=cycle30
}
C {devices/lab_pin.sym} 6540 -280 0 0 {name=l267 sig_type=std_logic lab=cycle31
}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Dr. Aubrey Beal, Dr. Phillip Bailey, Micah Tseng"
}
C {devices/opin.sym} 150 -100 0 0 {name=p2 lab=cycle[31..0]
}
C {devices/iopin.sym} 150 -130 0 0 {name=p3 lab=VSS
}
C {devices/iopin.sym} 150 -160 0 0 {name=p4 lab=VDD
}
C {devices/ipin.sym} 100 -160 0 0 {name=p5 lab=clk
}
C {devices/lab_pin.sym} 520 -280 2 0 {name=l8 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 720 -280 2 0 {name=l49 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 920 -280 2 0 {name=l53 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1120 -280 2 0 {name=l57 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1320 -280 2 0 {name=l61 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1520 -280 2 0 {name=l65 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1720 -280 2 0 {name=l69 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 1920 -280 2 0 {name=l73 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 2120 -280 2 0 {name=l77 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 2320 -280 2 0 {name=l81 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 2520 -280 2 0 {name=l85 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 2740 -280 2 0 {name=l89 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3140 -280 2 0 {name=l92 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3140 -280 2 0 {name=l93 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3340 -280 2 0 {name=l97 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3540 -280 2 0 {name=l101 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3740 -280 2 0 {name=l105 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 3940 -280 2 0 {name=l109 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4140 -280 2 0 {name=l113 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4340 -280 2 0 {name=l117 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4540 -280 2 0 {name=l121 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4740 -280 2 0 {name=l125 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 4940 -280 2 0 {name=l129 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5140 -280 2 0 {name=l134 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5340 -280 2 0 {name=l138 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5540 -280 2 0 {name=l143 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5740 -280 2 0 {name=l147 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 5940 -280 2 0 {name=l151 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 6140 -280 2 0 {name=l156 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 6340 -280 2 0 {name=l160 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 320 -270 2 0 {name=l42 sig_type=std_logic lab=reset_b
}
C {devices/ipin.sym} 100 -100 0 0 {name=p6 lab=reset
}
C {devices/lab_pin.sym} 2940 -280 2 0 {name=l43 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/dfrtp_1.sym} 410 -330 0 0 {name=x32 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 610 -330 0 0 {name=x1 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 810 -330 0 0 {name=x2 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1010 -330 0 0 {name=x3 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1210 -330 0 0 {name=x4 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1410 -330 0 0 {name=x5 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1610 -330 0 0 {name=x6 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1810 -330 0 0 {name=x7 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2010 -330 0 0 {name=x8 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2210 -330 0 0 {name=x9 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2410 -330 0 0 {name=x10 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2610 -330 0 0 {name=x11 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2830 -330 0 0 {name=x12 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3030 -330 0 0 {name=x13 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3230 -330 0 0 {name=x14 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3430 -330 0 0 {name=x15 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3630 -330 0 0 {name=x16 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3830 -330 0 0 {name=x17 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 4030 -330 0 0 {name=x18 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 4230 -330 0 0 {name=x19 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 4430 -330 0 0 {name=x20 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 4630 -330 0 0 {name=x21 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 4830 -330 0 0 {name=x22 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 5030 -330 0 0 {name=x23 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 5230 -330 0 0 {name=x24 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 5430 -330 0 0 {name=x25 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 5630 -330 0 0 {name=x26 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 5830 -330 0 0 {name=x27 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 6030 -330 0 0 {name=x28 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 6230 -330 0 0 {name=x29 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 6430 -330 0 0 {name=x30 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 510 -390 0 0 {name=l184 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 710 -390 0 0 {name=l185 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 910 -390 0 0 {name=l186 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 1110 -390 0 0 {name=l187 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 80 -390 0 0 {name=l3 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 270 -280 0 0 {name=l44 sig_type=std_logic lab=cycle0
}
C {devices/lab_pin.sym} 90 -270 2 0 {name=l45 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/dfrtp_1.sym} 180 -330 0 0 {name=x31 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 620 -150 2 0 {name=l55 sig_type=std_logic lab=reset_b
}
C {devices/lab_pin.sym} 380 -170 0 0 {name=l56 sig_type=std_logic lab=reset_cycle
}
C {devices/lab_pin.sym} 380 -130 0 0 {name=l58 sig_type=std_logic lab=reset
}
C {sky130_stdcells/buf_16.sym} 570 -150 0 0 {name=x37 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/and2_4.sym} 450 -150 0 0 {name=x35 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtn_1.sym} 6650 -330 0 0 {name=x33 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 6550 -390 0 0 {name=l46 sig_type=std_logic lab=clk

}
C {devices/lab_pin.sym} 6760 -280 0 0 {name=l50 sig_type=std_logic lab=half_cycle
}
C {devices/lab_pin.sym} 6560 -280 2 0 {name=l52 sig_type=std_logic lab=reset_b
}
C {sky130_stdcells/nand2_1.sym} 950 -130 0 0 {name=x38 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 880 -150 0 0 {name=l48 sig_type=std_logic lab=half_cycle
}
C {devices/lab_pin.sym} 880 -110 0 0 {name=l59 sig_type=std_logic lab=cycle31
}
C {devices/lab_pin.sym} 1020 -130 2 0 {name=l60 sig_type=std_logic lab=reset_cycle
}
