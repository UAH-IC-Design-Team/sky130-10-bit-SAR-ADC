v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Dr. Aubrey Beal, Dr. Phillip Bailey, Micah Tseng"
}
C {devices/iopin.sym} 120 -300 0 0 {name=p1 lab=VDD
}
C {devices/opin.sym} 120 -240 0 0 {name=p2 lab=Vout
}
C {devices/ipin.sym} 90 -240 0 0 {name=p3 lab=Vin_p
}
C {devices/ipin.sym} 90 -220 0 0 {name=p4 lab=Vin_n
}
C {devices/iopin.sym} 120 -280 0 0 {name=p5 lab=VSS
}
