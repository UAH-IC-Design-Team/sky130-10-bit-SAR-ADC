v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 490 -370 510 -370 {
lab=clk}
N 510 -370 510 -350 {
lab=clk}
N 490 -310 510 -310 {
lab=reset}
N 770 -370 790 -370 {
lab=clk}
N 790 -370 790 -350 {
lab=clk}
N 690 -350 710 -350 {
lab=#net1}
N 710 -350 710 -330 {
lab=#net1}
N 710 -330 790 -330 {
lab=#net1}
N 770 -310 790 -310 {
lab=reset}
N 970 -350 990 -350 {
lab=#net2}
N 990 -350 990 -330 {
lab=#net2}
N 990 -330 1030 -330 {
lab=#net2}
N 1010 -370 1030 -370 {
lab=clk}
N 1030 -370 1030 -350 {
lab=clk}
N 1010 -310 1030 -310 {
lab=reset}
N 1250 -370 1270 -370 {
lab=clk}
N 1270 -370 1270 -350 {
lab=clk}
N 1210 -350 1230 -350 {
lab=#net3}
N 1230 -350 1230 -330 {
lab=#net3}
N 1230 -330 1270 -330 {
lab=#net3}
N 1250 -310 1270 -310 {
lab=reset}
N 1450 -350 1470 -350 {
lab=#net4}
N 1470 -350 1470 -330 {
lab=#net4}
N 1470 -330 1510 -330 {
lab=#net4}
N 1490 -370 1510 -370 {
lab=clk}
N 1510 -370 1510 -350 {
lab=clk}
N 1490 -310 1510 -310 {
lab=reset}
N 1730 -370 1750 -370 {
lab=clk}
N 1750 -370 1750 -350 {
lab=clk}
N 1690 -350 1710 -350 {
lab=#net5}
N 1710 -350 1710 -330 {
lab=#net5}
N 1710 -330 1750 -330 {
lab=#net5}
N 1730 -310 1750 -310 {
lab=reset}
N 1930 -350 1950 -350 {
lab=#net6}
N 1950 -350 1950 -330 {
lab=#net6}
N 1950 -330 1990 -330 {
lab=#net6}
N 1970 -370 1990 -370 {
lab=clk}
N 1990 -370 1990 -350 {
lab=clk}
N 1970 -310 1990 -310 {
lab=reset}
N 2210 -370 2230 -370 {
lab=clk}
N 2230 -370 2230 -350 {
lab=clk}
N 2170 -350 2190 -350 {
lab=#net7}
N 2190 -350 2190 -330 {
lab=#net7}
N 2190 -330 2230 -330 {
lab=#net7}
N 2210 -310 2230 -310 {
lab=reset}
N 2410 -350 2430 -350 {
lab=#net8}
N 2430 -350 2430 -330 {
lab=#net8}
N 2430 -330 2470 -330 {
lab=#net8}
N 2450 -370 2470 -370 {
lab=clk}
N 2470 -370 2470 -350 {
lab=clk}
N 2450 -310 2470 -310 {
lab=reset}
N 2690 -370 2710 -370 {
lab=clk}
N 2710 -370 2710 -350 {
lab=clk}
N 2650 -350 2670 -350 {
lab=#net9}
N 2670 -350 2670 -330 {
lab=#net9}
N 2670 -330 2710 -330 {
lab=#net9}
N 2690 -310 2710 -310 {
lab=reset}
N 2890 -350 2910 -350 {
lab=#net10}
N 2910 -350 2910 -330 {
lab=#net10}
N 2910 -330 2950 -330 {
lab=#net10}
N 2930 -370 2950 -370 {
lab=clk}
N 2950 -370 2950 -350 {
lab=clk}
N 2930 -310 2950 -310 {
lab=reset}
N 3170 -370 3190 -370 {
lab=clk}
N 3190 -370 3190 -350 {
lab=clk}
N 3130 -350 3150 -350 {
lab=#net11}
N 3150 -350 3150 -330 {
lab=#net11}
N 3150 -330 3190 -330 {
lab=#net11}
N 3170 -310 3190 -310 {
lab=reset}
N 3370 -350 3390 -350 {
lab=#net12}
N 3390 -350 3390 -330 {
lab=#net12}
N 3390 -330 3430 -330 {
lab=#net12}
N 3410 -370 3430 -370 {
lab=clk}
N 3430 -370 3430 -350 {
lab=clk}
N 3410 -310 3430 -310 {
lab=reset}
N 3650 -370 3670 -370 {
lab=clk}
N 3670 -370 3670 -350 {
lab=clk}
N 3610 -350 3630 -350 {
lab=#net13}
N 3630 -350 3630 -330 {
lab=#net13}
N 3630 -330 3670 -330 {
lab=#net13}
N 3650 -310 3670 -310 {
lab=reset}
N 3850 -350 3870 -350 {
lab=#net14}
N 3870 -350 3870 -330 {
lab=#net14}
N 3870 -330 3910 -330 {
lab=#net14}
N 3890 -370 3910 -370 {
lab=clk}
N 3910 -370 3910 -350 {
lab=clk}
N 3890 -310 3910 -310 {
lab=reset}
N 4130 -370 4150 -370 {
lab=clk}
N 4150 -370 4150 -350 {
lab=clk}
N 4090 -350 4110 -350 {
lab=#net15}
N 4110 -350 4110 -330 {
lab=#net15}
N 4110 -330 4150 -330 {
lab=#net15}
N 4130 -310 4150 -310 {
lab=reset}
N 480 -330 510 -330 {
lab=johnson_counter_loop}
N 4430 -350 4470 -350 {
lab=johnson_counter_loop}
N 4330 -350 4350 -350 {
lab=#net16}
N 710 -330 710 -270 {
lab=#net1}
N 670 -70 690 -70 {
lab=#net17}
N 670 -110 690 -110 {
lab=clk}
N 580 -70 590 -70 {
lab=sw_sample}
N 990 -90 1010 -90 {
lab=#net18}
N 1090 -90 1100 -90 {
lab=#net19}
N 1180 -90 1220 -90 {
lab=comparator_clk}
N 810 -90 820 -90 {
lab=#net20}
N 900 -90 910 -90 {
lab=#net21}
N 910 -250 930 -250 {
lab=#net22}
N 1010 -250 1020 -250 {
lab=#net23}
N 730 -250 740 -250 {
lab=#net24}
N 820 -250 830 -250 {
lab=#net25}
N 710 -270 710 -250 {}
N 710 -250 730 -250 {}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Dr. Aubrey Beal, Dr. Phillip Bailey, Micah Tseng"
}
C {devices/lab_pin.sym} 1020 -250 2 0 {name=l217 sig_type=std_logic lab=sw_sample
}
C {sky130_stdcells/dfrtp_1.sym} 600 -330 0 0 {name=x5 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 880 -330 0 0 {name=x7 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 490 -370 0 0 {name=l20 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 490 -310 0 0 {name=l22 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 770 -370 0 0 {name=l23 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 770 -310 0 0 {name=l24 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 1120 -330 0 0 {name=x8 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1360 -330 0 0 {name=x9 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1010 -370 0 0 {name=l27 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1010 -310 0 0 {name=l28 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 1250 -370 0 0 {name=l32 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1250 -310 0 0 {name=l33 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 1600 -330 0 0 {name=x10 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1840 -330 0 0 {name=x11 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1490 -370 0 0 {name=l34 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1490 -310 0 0 {name=l35 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 1730 -370 0 0 {name=l36 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1730 -310 0 0 {name=l37 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 2080 -330 0 0 {name=x12 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2320 -330 0 0 {name=x13 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1970 -370 0 0 {name=l38 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1970 -310 0 0 {name=l39 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 2210 -370 0 0 {name=l40 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 2210 -310 0 0 {name=l41 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 2560 -330 0 0 {name=x14 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2800 -330 0 0 {name=x15 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2450 -370 0 0 {name=l42 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 2450 -310 0 0 {name=l43 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 2690 -370 0 0 {name=l44 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 2690 -310 0 0 {name=l46 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 3040 -330 0 0 {name=x16 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3280 -330 0 0 {name=x17 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2930 -370 0 0 {name=l47 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 2930 -310 0 0 {name=l48 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 3170 -370 0 0 {name=l49 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 3170 -310 0 0 {name=l50 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 3520 -330 0 0 {name=x18 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3760 -330 0 0 {name=x19 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3410 -370 0 0 {name=l51 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 3410 -310 0 0 {name=l52 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 3650 -370 0 0 {name=l53 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 3650 -310 0 0 {name=l54 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 4000 -330 0 0 {name=x20 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3890 -370 0 0 {name=l55 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 3890 -310 0 0 {name=l56 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 4130 -370 0 0 {name=l57 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 4130 -310 0 0 {name=l58 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 480 -330 0 0 {name=l59 sig_type=std_logic lab=johnson_counter_loop

}
C {devices/lab_pin.sym} 4470 -350 2 0 {name=l60 sig_type=std_logic lab=johnson_counter_loop

}
C {sky130_stdcells/dfrtp_1.sym} 4240 -330 0 0 {name=x21 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/inv_1.sym} 4390 -350 0 0 {name=x22 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 670 -110 0 0 {name=l31 sig_type=std_logic lab=clk
}
C {sky130_stdcells/and2_1.sym} 750 -90 0 0 {name=x23 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/inv_1.sym} 630 -70 0 0 {name=x24 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 580 -70 0 0 {name=l61 sig_type=std_logic lab=sw_sample
}
C {devices/lab_pin.sym} 1220 -90 2 0 {name=l62 sig_type=std_logic lab=comparator_clk
}
C {devices/iopin.sym} 120 -130 0 0 {name=p1 lab=VDD
}
C {devices/ipin.sym} 60 -130 0 0 {name=p2 lab=clk
}
C {devices/opin.sym} 120 -70 0 0 {name=p3 lab=sw_sample
}
C {devices/iopin.sym} 120 -110 0 0 {name=p4 lab=VSS
}
C {devices/opin.sym} 120 -50 0 0 {name=p5 lab=comparator_clk
}
C {devices/ipin.sym} 60 -110 0 0 {name=p6 lab=reset
}
C {sky130_stdcells/buf_16.sym} 1140 -90 0 0 {name=x25 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_4.sym} 950 -90 0 0 {name=x26 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_8.sym} 1050 -90 0 0 {name=x27 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_2.sym} 860 -90 0 0 {name=x1 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_4.sym} 870 -250 0 0 {name=x2 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_8.sym} 970 -250 0 0 {name=x3 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_2.sym} 780 -250 0 0 {name=x4 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
