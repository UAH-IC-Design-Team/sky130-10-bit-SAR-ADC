v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 250 -360 270 -360 {
lab=clk}
N 270 -360 270 -340 {
lab=clk}
N 250 -300 270 -300 {
lab=reset}
N 530 -360 550 -360 {
lab=clk}
N 550 -360 550 -340 {
lab=clk}
N 450 -340 470 -340 {
lab=#net1}
N 470 -340 470 -320 {
lab=#net1}
N 470 -320 550 -320 {
lab=#net1}
N 530 -300 550 -300 {
lab=reset}
N 730 -340 750 -340 {
lab=#net2}
N 750 -340 750 -320 {
lab=#net2}
N 750 -320 790 -320 {
lab=#net2}
N 770 -360 790 -360 {
lab=clk}
N 790 -360 790 -340 {
lab=clk}
N 770 -300 790 -300 {
lab=reset}
N 1010 -360 1030 -360 {
lab=clk}
N 1030 -360 1030 -340 {
lab=clk}
N 970 -340 990 -340 {
lab=#net3}
N 990 -340 990 -320 {
lab=#net3}
N 990 -320 1030 -320 {
lab=#net3}
N 1010 -300 1030 -300 {
lab=reset}
N 1210 -340 1230 -340 {
lab=#net4}
N 1230 -340 1230 -320 {
lab=#net4}
N 1230 -320 1270 -320 {
lab=#net4}
N 1250 -360 1270 -360 {
lab=clk}
N 1270 -360 1270 -340 {
lab=clk}
N 1250 -300 1270 -300 {
lab=reset}
N 1490 -360 1510 -360 {
lab=clk}
N 1510 -360 1510 -340 {
lab=clk}
N 1450 -340 1470 -340 {
lab=#net5}
N 1470 -340 1470 -320 {
lab=#net5}
N 1470 -320 1510 -320 {
lab=#net5}
N 1490 -300 1510 -300 {
lab=reset}
N 1690 -340 1710 -340 {
lab=#net6}
N 1710 -340 1710 -320 {
lab=#net6}
N 1710 -320 1750 -320 {
lab=#net6}
N 1730 -360 1750 -360 {
lab=clk}
N 1750 -360 1750 -340 {
lab=clk}
N 1730 -300 1750 -300 {
lab=reset}
N 1970 -360 1990 -360 {
lab=clk}
N 1990 -360 1990 -340 {
lab=clk}
N 1930 -340 1950 -340 {
lab=#net7}
N 1950 -340 1950 -320 {
lab=#net7}
N 1950 -320 1990 -320 {
lab=#net7}
N 1970 -300 1990 -300 {
lab=reset}
N 2170 -340 2190 -340 {
lab=#net8}
N 2190 -340 2190 -320 {
lab=#net8}
N 2190 -320 2230 -320 {
lab=#net8}
N 2210 -360 2230 -360 {
lab=clk}
N 2230 -360 2230 -340 {
lab=clk}
N 2210 -300 2230 -300 {
lab=reset}
N 2450 -360 2470 -360 {
lab=clk}
N 2470 -360 2470 -340 {
lab=clk}
N 2410 -340 2430 -340 {
lab=#net9}
N 2430 -340 2430 -320 {
lab=#net9}
N 2430 -320 2470 -320 {
lab=#net9}
N 2450 -300 2470 -300 {
lab=reset}
N 2650 -340 2670 -340 {
lab=#net10}
N 2670 -340 2670 -320 {
lab=#net10}
N 2670 -320 2710 -320 {
lab=#net10}
N 2690 -360 2710 -360 {
lab=clk}
N 2710 -360 2710 -340 {
lab=clk}
N 2690 -300 2710 -300 {
lab=reset}
N 2930 -360 2950 -360 {
lab=clk}
N 2950 -360 2950 -340 {
lab=clk}
N 2890 -340 2910 -340 {
lab=#net11}
N 2910 -340 2910 -320 {
lab=#net11}
N 2910 -320 2950 -320 {
lab=#net11}
N 2930 -300 2950 -300 {
lab=reset}
N 3130 -340 3150 -340 {
lab=#net12}
N 3150 -340 3150 -320 {
lab=#net12}
N 3150 -320 3190 -320 {
lab=#net12}
N 3170 -360 3190 -360 {
lab=clk}
N 3190 -360 3190 -340 {
lab=clk}
N 3170 -300 3190 -300 {
lab=reset}
N 3410 -360 3430 -360 {
lab=clk}
N 3430 -360 3430 -340 {
lab=clk}
N 3370 -340 3390 -340 {
lab=#net13}
N 3390 -340 3390 -320 {
lab=#net13}
N 3390 -320 3430 -320 {
lab=#net13}
N 3410 -300 3430 -300 {
lab=reset}
N 3610 -340 3630 -340 {
lab=#net14}
N 3630 -340 3630 -320 {
lab=#net14}
N 3630 -320 3670 -320 {
lab=#net14}
N 3650 -360 3670 -360 {
lab=clk}
N 3670 -360 3670 -340 {
lab=clk}
N 3650 -300 3670 -300 {
lab=reset}
N 3890 -360 3910 -360 {
lab=clk}
N 3910 -360 3910 -340 {
lab=clk}
N 3850 -340 3870 -340 {
lab=#net15}
N 3870 -340 3870 -320 {
lab=#net15}
N 3870 -320 3910 -320 {
lab=#net15}
N 3890 -300 3910 -300 {
lab=reset}
N 240 -320 270 -320 {
lab=johnson_counter_loop}
N 4190 -340 4230 -340 {
lab=johnson_counter_loop}
N 4090 -340 4110 -340 {
lab=#net16}
N 470 -320 470 -260 {
lab=#net1}
N 670 -70 690 -70 {
lab=#net17}
N 670 -110 690 -110 {
lab=#net18}
N 580 -70 590 -70 {
lab=sw_sample}
N 990 -90 1010 -90 {
lab=#net19}
N 1090 -90 1100 -90 {
lab=#net20}
N 1180 -90 1220 -90 {
lab=comparator_clk}
N 810 -90 820 -90 {
lab=#net21}
N 900 -90 910 -90 {
lab=#net22}
N 670 -240 690 -240 {
lab=#net23}
N 770 -240 780 -240 {
lab=sw_sample}
N 490 -240 500 -240 {
lab=#net1}
N 580 -240 590 -240 {
lab=#net24}
N 470 -260 470 -240 {
lab=#net1}
N 470 -240 490 -240 {
lab=#net1}
N 630 -110 670 -110 {
lab=#net18}
N 540 -110 550 -110 {
lab=#net25}
N 450 -110 460 -110 {
lab=#net26}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Dr. Aubrey Beal, Dr. Phillip Bailey, Micah Tseng"
}
C {devices/lab_pin.sym} 780 -240 2 0 {name=l217 sig_type=std_logic lab=sw_sample
}
C {sky130_stdcells/dfrtp_1.sym} 360 -320 0 0 {name=x5 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 640 -320 0 0 {name=x7 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 250 -360 0 0 {name=l20 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 250 -300 0 0 {name=l22 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 530 -360 0 0 {name=l23 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 530 -300 0 0 {name=l24 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 880 -320 0 0 {name=x8 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1120 -320 0 0 {name=x9 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 770 -360 0 0 {name=l27 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 770 -300 0 0 {name=l28 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 1010 -360 0 0 {name=l32 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1010 -300 0 0 {name=l33 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 1360 -320 0 0 {name=x10 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 1600 -320 0 0 {name=x11 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1250 -360 0 0 {name=l34 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1250 -300 0 0 {name=l35 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 1490 -360 0 0 {name=l36 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1490 -300 0 0 {name=l37 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 1840 -320 0 0 {name=x12 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2080 -320 0 0 {name=x13 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 1730 -360 0 0 {name=l38 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1730 -300 0 0 {name=l39 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 1970 -360 0 0 {name=l40 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 1970 -300 0 0 {name=l41 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 2320 -320 0 0 {name=x14 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 2560 -320 0 0 {name=x15 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2210 -360 0 0 {name=l42 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 2210 -300 0 0 {name=l43 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 2450 -360 0 0 {name=l44 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 2450 -300 0 0 {name=l46 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 2800 -320 0 0 {name=x16 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3040 -320 0 0 {name=x17 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 2690 -360 0 0 {name=l47 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 2690 -300 0 0 {name=l48 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 2930 -360 0 0 {name=l49 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 2930 -300 0 0 {name=l50 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 3280 -320 0 0 {name=x18 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/dfrtp_1.sym} 3520 -320 0 0 {name=x19 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3170 -360 0 0 {name=l51 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 3170 -300 0 0 {name=l52 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 3410 -360 0 0 {name=l53 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 3410 -300 0 0 {name=l54 sig_type=std_logic lab=reset
}
C {sky130_stdcells/dfrtp_1.sym} 3760 -320 0 0 {name=x20 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 3650 -360 0 0 {name=l55 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 3650 -300 0 0 {name=l56 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 3890 -360 0 0 {name=l57 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 3890 -300 0 0 {name=l58 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} 240 -320 0 0 {name=l59 sig_type=std_logic lab=johnson_counter_loop

}
C {devices/lab_pin.sym} 4230 -340 2 0 {name=l60 sig_type=std_logic lab=johnson_counter_loop

}
C {sky130_stdcells/dfrtp_1.sym} 4000 -320 0 0 {name=x21 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/inv_1.sym} 4150 -340 0 0 {name=x22 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 450 -110 0 0 {name=l31 sig_type=std_logic lab=clk
}
C {sky130_stdcells/and2_1.sym} 750 -90 0 0 {name=x23 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/inv_1.sym} 630 -70 0 0 {name=x24 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {devices/lab_pin.sym} 580 -70 0 0 {name=l61 sig_type=std_logic lab=sw_sample
}
C {devices/lab_pin.sym} 1220 -90 2 0 {name=l62 sig_type=std_logic lab=comparator_clk
}
C {devices/iopin.sym} 120 -130 0 0 {name=p1 lab=VDD
}
C {devices/ipin.sym} 60 -130 0 0 {name=p2 lab=clk
}
C {devices/opin.sym} 120 -70 0 0 {name=p3 lab=sw_sample
}
C {devices/iopin.sym} 120 -110 0 0 {name=p4 lab=VSS
}
C {devices/opin.sym} 120 -50 0 0 {name=p5 lab=comparator_clk
}
C {devices/ipin.sym} 60 -110 0 0 {name=p6 lab=reset
}
C {sky130_stdcells/buf_16.sym} 1140 -90 0 0 {name=x25 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_4.sym} 950 -90 0 0 {name=x26 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_8.sym} 1050 -90 0 0 {name=x27 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_2.sym} 860 -90 0 0 {name=x1 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_4.sym} 630 -240 0 0 {name=x2 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_8.sym} 730 -240 0 0 {name=x3 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/buf_2.sym} 540 -240 0 0 {name=x4 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/clkdlybuf4s50_1.sym} 590 -110 0 0 {name=x6 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
C {sky130_stdcells/clkdlybuf4s50_1.sym} 500 -110 0 0 {name=x28 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ 
}
